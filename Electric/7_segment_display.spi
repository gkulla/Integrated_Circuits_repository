*** SPICE deck for cell 7_segment_display{lay} from library prova_library4_Nand_lay
*** Created on Fri Dec 04, 2015 17:12:39
*** Last revised on Wed Dec 09, 2015 15:47:35
*** Written on Wed Dec 09, 2015 15:56:24 by Electric VLSI Design System, version 9.06
*** Layout tech: mocmos, foundry MOSIS
*** UC SPICE *** , MIN_RESIST 4.0, MIN_CAPAC 0.1FF
***    P-Active:	areacap=0.9FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    N-Active:	areacap=0.9FF/um^2,	edgecap=0.0FF/um,	res=3.0ohms/sq
***    Polysilicon-1:	areacap=0.1467FF/um^2,	edgecap=0.0608FF/um,	res=6.2ohms/sq
***    Polysilicon-2:	areacap=1.0FF/um^2,	edgecap=0.0FF/um,	res=50.0ohms/sq
***    Transistor-Poly:	areacap=0.09FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    Poly-Cut:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=2.2ohms/sq
***    Active-Cut:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=2.5ohms/sq
***    Metal-1:	areacap=0.1209FF/um^2,	edgecap=0.1104FF/um,	res=0.078ohms/sq
***    Via1:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=1.0ohms/sq
***    Metal-2:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via2:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.9ohms/sq
***    Metal-3:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via3:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-4:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via4:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-5:	areacap=0.0843FF/um^2,	edgecap=0.0974FF/um,	res=0.078ohms/sq
***    Via5:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=0.8ohms/sq
***    Metal-6:	areacap=0.0423FF/um^2,	edgecap=0.1273FF/um,	res=0.036ohms/sq
***    Hi-Res:	areacap=0.0FF/um^2,	edgecap=0.0FF/um,	res=1.0ohms/sq

*** TOP LEVEL CELL: 7_segment_display{lay}
Mnmos@0 gnd net@4#2nmos@0_poly-right net@0 gnd n L=0.7U W=1.75U AS=1.531P AD=16.794P PS=3.5U PD=23.877U
Mnmos@1 net@0 net@1#2nmos@1_poly-left net@14 gnd n L=0.7U W=1.75U AS=7.248P AD=1.531P PS=10.85U PD=3.5U
Mnmos@2 gnd net@14#12nmos@2_poly-left net@22 gnd n L=0.7U W=1.75U AS=6.431P AD=16.794P PS=10.15U PD=23.877U
Mnmos@3 gnd X3#4nmos@3_poly-right net@47 gnd n L=0.7U W=1.75U AS=1.531P AD=16.794P PS=3.5U PD=23.877U
Mnmos@4 net@47 X1#2nmos@4_poly-left net@53 gnd n L=0.7U W=1.75U AS=7.248P AD=1.531P PS=10.85U PD=3.5U
Mnmos@5 gnd net@53#12nmos@5_poly-left net@62 gnd n L=0.7U W=1.75U AS=6.431P AD=16.794P PS=10.15U PD=23.877U
Mnmos@6 net@103 net@22#10nmos@6_poly-right gnd gnd n L=0.7U W=1.75U AS=16.794P AD=4.961P PS=23.877U PD=8.12U
Mnmos@7 gnd net@62#10nmos@7_poly-left net@103 gnd n L=0.7U W=1.75U AS=4.961P AD=16.794P PS=8.12U PD=23.877U
Mnmos@8 net@103 X2#3nmos@8_poly-left gnd gnd n L=0.7U W=1.75U AS=16.794P AD=4.961P PS=23.877U PD=8.12U
Mnmos@9 Y1 net@103#11nmos@9_poly-left gnd gnd n L=0.7U W=1.75U AS=16.794P AD=6.737P PS=23.877U PD=10.325U
Mnmos@10 gnd X4#4nmos@10_poly-left net@103 gnd n L=0.7U W=1.75U AS=4.961P AD=16.794P PS=8.12U PD=23.877U
Mnmos@11 gnd X1#12nmos@11_poly-left net@1 gnd n L=0.7U W=1.75U AS=5.972P AD=16.794P PS=9.8U PD=23.877U
Mnmos@12 gnd X3#11nmos@12_poly-left net@4#4pin@22_polysilicon-1 gnd n L=0.7U W=1.75U AS=5.972P AD=16.794P PS=9.8U PD=23.877U
Mnmos@13 net@241 X4#15nmos@13_poly-right gnd gnd n L=0.7U W=1.75U AS=16.794P AD=4.961P PS=23.877U PD=8.12U
Mnmos@14 gnd net@275 net@241 gnd n L=0.7U W=1.75U AS=4.961P AD=16.794P PS=8.12U PD=23.877U
Mnmos@15 net@241 net@255#3nmos@15_poly-left gnd gnd n L=0.7U W=1.75U AS=16.794P AD=4.961P PS=23.877U PD=8.12U
Mnmos@16 Y2 net@241#11nmos@16_poly-left gnd gnd n L=0.7U W=1.75U AS=16.794P AD=6.737P PS=23.877U PD=10.325U
Mnmos@17 gnd net@254#4nmos@17_poly-left net@241 gnd n L=0.7U W=1.75U AS=4.961P AD=16.794P PS=8.12U PD=23.877U
Mnmos@18 gnd net@352#2nmos@18_poly-right net@320 gnd n L=0.7U W=1.75U AS=1.531P AD=16.794P PS=3.5U PD=23.877U
Mnmos@19 net@320 net@321 net@325 gnd n L=0.7U W=1.75U AS=7.248P AD=1.531P PS=10.85U PD=3.5U
Mnmos@20 gnd net@325#12nmos@20_poly-left net@255 gnd n L=0.7U W=1.75U AS=6.431P AD=16.794P PS=10.15U PD=23.877U
Mnmos@21 gnd X1#26nmos@21_poly-right net@362 gnd n L=0.7U W=1.75U AS=1.531P AD=16.794P PS=3.5U PD=23.877U
Mnmos@22 net@362 X2#13nmos@22_poly-left net@367 gnd n L=0.7U W=1.75U AS=7.248P AD=1.531P PS=10.85U PD=3.5U
Mnmos@23 gnd net@367#12nmos@23_poly-left net@254#1contact@66_metal-1-polysilicon-1 gnd n L=0.7U W=1.75U AS=6.431P AD=16.794P PS=10.15U PD=23.877U
Mnmos@24 gnd X2#22nmos@24_poly-left net@321#7contact@92_metal-1-p-act gnd n L=0.7U W=1.75U AS=5.972P AD=16.794P PS=9.8U PD=23.877U
Mnmos@25 gnd X1#33nmos@25_poly-left net@352#7contact@97_metal-1-p-act gnd n L=0.7U W=1.75U AS=5.972P AD=16.794P PS=9.8U PD=23.877U
Mnmos@26 gnd X3#20nmos@26_poly-left net@275#13pin@236_metal-1 gnd n L=0.7U W=1.75U AS=5.972P AD=16.794P PS=9.8U PD=23.877U
Mnmos@27 Y3 net@352#23nmos@27_poly-right net@495 gnd n L=0.7U W=1.75U AS=1.378P AD=6.676P PS=3.675U PD=9.17U
Mnmos@28 net@495 net@275#26nmos@28_poly-left net@504 gnd n L=0.7U W=1.75U AS=1.317P AD=1.378P PS=3.325U PD=3.675U
Mnmos@29 net@504 net@517 net@505 gnd n L=0.7U W=1.75U AS=1.347P AD=1.317P PS=3.5U PD=3.325U
Mnmos@30 net@505 X2#35nmos@30_poly-left gnd gnd n L=0.7U W=1.75U AS=16.794P AD=1.347P PS=23.877U PD=3.5U
Mnmos@31 gnd X4#29nmos@31_poly-left net@517#4contact@122_metal-1-polysilicon-1 gnd n L=0.7U W=1.75U AS=5.972P AD=16.794P PS=9.8U PD=23.877U
Mnmos@32 gnd net@612#5pin@305_polysilicon-1 net@587 gnd n L=0.7U W=1.75U AS=4.134P AD=16.794P PS=6.767U PD=23.877U
Mnmos@33 net@587 X4#37nmos@33_poly-right gnd gnd n L=0.7U W=1.75U AS=16.794P AD=4.134P PS=23.877U PD=6.767U
Mnmos@34 gnd net@607 net@587 gnd n L=0.7U W=1.75U AS=4.134P AD=16.794P PS=6.767U PD=23.877U
Mnmos@35 Y4 net@587#18nmos@35_poly-left gnd gnd n L=0.7U W=1.75U AS=16.794P AD=6.737P PS=23.877U PD=10.325U
Mnmos@36 net@587 net@603#7nmos@36_poly-left gnd gnd n L=0.7U W=1.75U AS=16.794P AD=4.134P PS=23.877U PD=6.767U
Mnmos@37 gnd net@597#4nmos@37_poly-left net@587 gnd n L=0.7U W=1.75U AS=4.134P AD=16.794P PS=6.767U PD=23.877U
Mnmos@38 net@696 X3#26nmos@38_poly-left net@676 gnd n L=0.7U W=1.75U AS=1.531P AD=1.378P PS=3.5U PD=3.325U
Mnmos@39 net@676 X1#44nmos@39_poly-left gnd gnd n L=0.7U W=1.75U AS=16.794P AD=1.531P PS=23.877U PD=3.5U
Mnmos@40 gnd net@679#7nmos@40_poly-left net@607#3pin@349_polysilicon-1 gnd n L=0.7U W=1.75U AS=6.431P AD=16.794P PS=10.15U PD=23.877U
Mnmos@41 net@679 net@705 net@696 gnd n L=0.7U W=1.75U AS=1.378P AD=6.508P PS=3.325U PD=8.75U
Mnmos@42 gnd net@759#2nmos@42_poly-right net@747 gnd n L=0.7U W=1.75U AS=1.531P AD=16.794P PS=3.5U PD=23.877U
Mnmos@43 net@747 net@352#38nmos@43_poly-left net@738 gnd n L=0.7U W=1.75U AS=7.248P AD=1.531P PS=10.85U PD=3.5U
Mnmos@44 gnd net@738#5nmos@44_poly-left net@597 gnd n L=0.7U W=1.75U AS=6.431P AD=16.794P PS=10.15U PD=23.877U
Mnmos@45 gnd net@806#2nmos@45_poly-right net@794 gnd n L=0.7U W=1.75U AS=1.531P AD=16.794P PS=3.5U PD=23.877U
Mnmos@46 net@794 X2#51nmos@46_poly-left net@785 gnd n L=0.7U W=1.75U AS=7.248P AD=1.531P PS=10.85U PD=3.5U
Mnmos@47 gnd net@785#5nmos@47_poly-left net@603#4contact@140_metal-1-polysilicon-1 gnd n L=0.7U W=1.75U AS=6.431P AD=16.794P PS=10.15U PD=23.877U
Mnmos@48 gnd X2#57nmos@48_poly-right net@841 gnd n L=0.7U W=1.75U AS=1.531P AD=16.794P PS=3.5U PD=23.877U
Mnmos@49 net@841 net@352#48nmos@49_poly-left net@832 gnd n L=0.7U W=1.75U AS=7.248P AD=1.531P PS=10.85U PD=3.5U
Mnmos@50 gnd net@832#5nmos@50_poly-left net@612#10contact@192_metal-1-p-act gnd n L=0.7U W=1.75U AS=6.431P AD=16.794P PS=10.15U PD=23.877U
Mnmos@51 gnd X3#36nmos@51_poly-left net@806#4pin@426_polysilicon-1 gnd n L=0.7U W=1.75U AS=5.972P AD=16.794P PS=9.8U PD=23.877U
Mnmos@52 gnd X3#41nmos@52_poly-left net@759#4pin@404_polysilicon-1 gnd n L=0.7U W=1.75U AS=5.972P AD=16.794P PS=9.8U PD=23.877U
Mnmos@53 gnd X2#66nmos@53_poly-left net@705#6contact@160_metal-1-polysilicon-1 gnd n L=0.7U W=1.75U AS=5.972P AD=16.794P PS=9.8U PD=23.877U
Mnmos@54 gnd X1#57nmos@54_poly-left Y5 gnd n L=0.7U W=1.75U AS=5.972P AD=16.794P PS=9.8U PD=23.877U
Mnmos@55 net@995 X4#50nmos@55_poly-right gnd gnd n L=0.7U W=1.75U AS=16.794P AD=4.961P PS=23.877U PD=8.12U
Mnmos@56 gnd net@984#6nmos@56_poly-left net@995 gnd n L=0.7U W=1.75U AS=4.961P AD=16.794P PS=8.12U PD=23.877U
Mnmos@57 net@995 net@983#4nmos@57_poly-left gnd gnd n L=0.7U W=1.75U AS=16.794P AD=4.961P PS=23.877U PD=8.12U
Mnmos@58 Y6 net@995#11nmos@58_poly-left gnd gnd n L=0.7U W=1.75U AS=16.794P AD=6.737P PS=23.877U PD=10.325U
Mnmos@59 gnd net@1008#4nmos@59_poly-left net@995 gnd n L=0.7U W=1.75U AS=4.961P AD=16.794P PS=8.12U PD=23.877U
Mnmos@60 gnd net@1072#2nmos@60_poly-right net@1060 gnd n L=0.7U W=1.75U AS=1.531P AD=16.794P PS=3.5U PD=23.877U
Mnmos@61 net@1060 net@352#56nmos@61_poly-left net@1068 gnd n L=0.7U W=1.75U AS=7.248P AD=1.531P PS=10.85U PD=3.5U
Mnmos@62 gnd net@1068#13nmos@62_poly-left net@984 gnd n L=0.7U W=1.75U AS=6.431P AD=16.794P PS=10.15U PD=23.877U
Mnmos@63 gnd X3#51nmos@63_poly-right net@1107 gnd n L=0.7U W=1.75U AS=1.531P AD=16.794P PS=3.5U PD=23.877U
Mnmos@64 net@1107 net@352#66nmos@64_poly-left net@1115 gnd n L=0.7U W=1.75U AS=7.248P AD=1.531P PS=10.85U PD=3.5U
Mnmos@65 gnd net@1115#13nmos@65_poly-left net@983#2contact@228_metal-1-polysilicon-1 gnd n L=0.7U W=1.75U AS=6.431P AD=16.794P PS=10.15U PD=23.877U
Mnmos@66 gnd X3#60nmos@66_poly-right net@1154 gnd n L=0.7U W=1.75U AS=1.531P AD=16.794P PS=3.5U PD=23.877U
Mnmos@67 net@1154 net@1072#13nmos@67_poly-left net@1162 gnd n L=0.7U W=1.75U AS=7.248P AD=1.531P PS=10.85U PD=3.5U
Mnmos@68 gnd net@1162#13nmos@68_poly-left net@1008#1contact@229_metal-1-polysilicon-1 gnd n L=0.7U W=1.75U AS=6.431P AD=16.794P PS=10.15U PD=23.877U
Mnmos@69 gnd X2#76nmos@69_poly-left net@1072#4pin@571_polysilicon-1 gnd n L=0.7U W=1.75U AS=5.972P AD=16.794P PS=9.8U PD=23.877U
Mnmos@70 net@1252 net@1246#3nmos@70_poly-right gnd gnd n L=0.7U W=1.75U AS=16.794P AD=4.961P PS=23.877U PD=8.12U
Mnmos@71 gnd X4#63nmos@71_poly-left net@1252 gnd n L=0.7U W=1.75U AS=4.961P AD=16.794P PS=8.12U PD=23.877U
Mnmos@72 net@1252 net@1240#4nmos@72_poly-left gnd gnd n L=0.7U W=1.75U AS=16.794P AD=4.961P PS=23.877U PD=8.12U
Mnmos@73 Y7 net@1252#11nmos@73_poly-left gnd gnd n L=0.7U W=1.75U AS=16.794P AD=6.737P PS=23.877U PD=10.325U
Mnmos@74 gnd net@1265#4nmos@74_poly-left net@1252 gnd n L=0.7U W=1.75U AS=4.961P AD=16.794P PS=8.12U PD=23.877U
Mnmos@75 gnd X2#81nmos@75_poly-right net@1317 gnd n L=0.7U W=1.75U AS=1.531P AD=16.794P PS=3.5U PD=23.877U
Mnmos@76 net@1317 net@352#76nmos@76_poly-left net@1325 gnd n L=0.7U W=1.75U AS=7.248P AD=1.531P PS=10.85U PD=3.5U
Mnmos@77 gnd net@1325#13nmos@77_poly-left net@1240#2contact@285_metal-1-polysilicon-1 gnd n L=0.7U W=1.75U AS=6.431P AD=16.794P PS=10.15U PD=23.877U
Mnmos@78 gnd X2#90nmos@78_poly-right net@1364 gnd n L=0.7U W=1.75U AS=1.531P AD=16.794P PS=3.5U PD=23.877U
Mnmos@79 net@1364 net@1365#4nmos@79_poly-left net@1372 gnd n L=0.7U W=1.75U AS=7.248P AD=1.531P PS=10.85U PD=3.5U
Mnmos@80 gnd net@1372#13nmos@80_poly-left net@1265#1contact@286_metal-1-polysilicon-1 gnd n L=0.7U W=1.75U AS=6.431P AD=16.794P PS=10.15U PD=23.877U
Mnmos@81 gnd net@1423#2nmos@81_poly-right net@1411 gnd n L=0.7U W=1.75U AS=1.531P AD=16.794P PS=3.5U PD=23.877U
Mnmos@82 net@1411 X3#73nmos@82_poly-left net@1419 gnd n L=0.7U W=1.75U AS=7.248P AD=1.531P PS=10.85U PD=3.5U
Mnmos@83 gnd net@1419#13nmos@83_poly-left net@1246 gnd n L=0.7U W=1.75U AS=6.431P AD=16.794P PS=10.15U PD=23.877U
Mnmos@84 gnd X3#81nmos@84_poly-left net@1365 gnd n L=0.7U W=1.75U AS=5.972P AD=16.794P PS=9.8U PD=23.877U
Mnmos@85 gnd X2#99nmos@85_poly-left net@1423#4pin@748_polysilicon-1 gnd n L=0.7U W=1.75U AS=5.972P AD=16.794P PS=9.8U PD=23.877U
Mpmos@0 net@14 net@4 vdd vdd p L=0.7U W=3.5U AS=19.469P AD=7.248P PS=25.03U PD=10.85U
Mpmos@1 vdd net@1#3pin@3_polysilicon-1 net@14 vdd p L=0.7U W=3.5U AS=7.248P AD=19.469P PS=10.85U PD=25.03U
Mpmos@2 vdd net@14#6pmos@2_poly-right net@22 vdd p L=0.7U W=3.5U AS=6.431P AD=19.469P PS=10.15U PD=25.03U
Mpmos@3 net@53 X3#2pmos@3_poly-right vdd vdd p L=0.7U W=3.5U AS=19.469P AD=7.248P PS=25.03U PD=10.85U
Mpmos@4 vdd X1#3pin@26_polysilicon-1 net@53 vdd p L=0.7U W=3.5U AS=7.248P AD=19.469P PS=10.85U PD=25.03U
Mpmos@5 vdd net@53#6pmos@5_poly-right net@62 vdd p L=0.7U W=3.5U AS=6.431P AD=19.469P PS=10.15U PD=25.03U
Mpmos@6 net@103 net@22#12pmos@6_poly-right net@99 vdd p L=0.7U W=3.5U AS=3.369P AD=4.961P PS=5.425U PD=8.12U
Mpmos@7 net@99 net@62#6pmos@7_poly-left net@112 vdd p L=0.7U W=3.5U AS=3.062P AD=3.369P PS=5.25U PD=5.425U
Mpmos@8 net@112 X2#7pmos@8_poly-right net@132 vdd p L=0.7U W=3.5U AS=3.062P AD=3.062P PS=5.25U PD=5.25U
Mpmos@9 Y1 net@103#5pmos@9_poly-right vdd vdd p L=0.7U W=3.5U AS=19.469P AD=6.737P PS=25.03U PD=10.325U
Mpmos@10 net@132 X4#7pmos@10_poly-right vdd vdd p L=0.7U W=3.5U AS=19.469P AD=3.062P PS=25.03U PD=5.25U
Mpmos@11 vdd X1#10pmos@11_poly-right net@1 vdd p L=0.7U W=3.5U AS=5.972P AD=19.469P PS=9.8U PD=25.03U
Mpmos@12 vdd X3#9pmos@12_poly-right net@4#4pin@22_polysilicon-1 vdd p L=0.7U W=3.5U AS=5.972P AD=19.469P PS=9.8U PD=25.03U
Mpmos@13 net@241 X4#17pmos@13_poly-right net@319 vdd p L=0.7U W=3.5U AS=3.369P AD=4.961P PS=5.425U PD=8.12U
Mpmos@14 net@319 net@275#4pmos@14_poly-right net@250 vdd p L=0.7U W=3.5U AS=3.062P AD=3.369P PS=5.25U PD=5.425U
Mpmos@15 net@250 net@255#7pmos@15_poly-right net@270 vdd p L=0.7U W=3.5U AS=3.062P AD=3.062P PS=5.25U PD=5.25U
Mpmos@16 Y2 net@241#5pmos@16_poly-right vdd vdd p L=0.7U W=3.5U AS=19.469P AD=6.737P PS=25.03U PD=10.325U
Mpmos@17 net@270 net@254#7pmos@17_poly-right vdd vdd p L=0.7U W=3.5U AS=19.469P AD=3.062P PS=25.03U PD=5.25U
Mpmos@18 net@325 net@352 vdd vdd p L=0.7U W=3.5U AS=19.469P AD=7.248P PS=25.03U PD=10.85U
Mpmos@19 vdd net@321#1pin@169_polysilicon-1 net@325 vdd p L=0.7U W=3.5U AS=7.248P AD=19.469P PS=10.85U PD=25.03U
Mpmos@20 vdd net@325#6pmos@20_poly-right net@255 vdd p L=0.7U W=3.5U AS=6.431P AD=19.469P PS=10.15U PD=25.03U
Mpmos@21 net@367 X1#24pmos@21_poly-right vdd vdd p L=0.7U W=3.5U AS=19.469P AD=7.248P PS=25.03U PD=10.85U
Mpmos@22 vdd X2#14pin@188_polysilicon-1 net@367 vdd p L=0.7U W=3.5U AS=7.248P AD=19.469P PS=10.85U PD=25.03U
Mpmos@23 vdd net@367#6pmos@23_poly-right net@254#1contact@66_metal-1-polysilicon-1 vdd p L=0.7U W=3.5U AS=6.431P AD=19.469P PS=10.15U PD=25.03U
Mpmos@24 vdd X2#20pmos@24_poly-right net@321#7contact@92_metal-1-p-act vdd p L=0.7U W=3.5U AS=5.972P AD=19.469P PS=9.8U PD=25.03U
Mpmos@25 vdd X1#31pmos@25_poly-right net@352#7contact@97_metal-1-p-act vdd p L=0.7U W=3.5U AS=5.972P AD=19.469P PS=9.8U PD=25.03U
Mpmos@26 vdd X3#18pmos@26_poly-right net@275#13pin@236_metal-1 vdd p L=0.7U W=3.5U AS=5.972P AD=19.469P PS=9.8U PD=25.03U
Mpmos@27 Y3 net@352#21pmos@27_poly-right vdd vdd p L=0.7U W=3.5U AS=19.469P AD=6.676P PS=25.03U PD=9.17U
Mpmos@28 vdd net@275#22pin@251_polysilicon-1 Y3 vdd p L=0.7U W=3.5U AS=6.676P AD=19.469P PS=9.17U PD=25.03U
Mpmos@29 Y3 net@517#3pmos@29_poly-right vdd vdd p L=0.7U W=3.5U AS=19.469P AD=6.676P PS=25.03U PD=9.17U
Mpmos@30 vdd X2#33pin@255_polysilicon-1 Y3 vdd p L=0.7U W=3.5U AS=6.676P AD=19.469P PS=9.17U PD=25.03U
Mpmos@31 vdd X4#27pmos@31_poly-right net@517#4contact@122_metal-1-polysilicon-1 vdd p L=0.7U W=3.5U AS=5.972P AD=19.469P PS=9.8U PD=25.03U
Mpmos@32 net@587 net@612 net@593 vdd p L=0.7U W=3.5U AS=3.369P AD=4.134P PS=5.425U PD=6.767U
Mpmos@33 net@593 X4#40pmos@33_poly-right net@628 vdd p L=0.7U W=3.5U AS=2.756P AD=3.369P PS=5.075U PD=5.425U
Mpmos@34 net@628 net@607#8pmos@34_poly-right net@646 vdd p L=0.7U W=3.5U AS=3.369P AD=2.756P PS=5.425U PD=5.075U
Mpmos@35 Y4 net@587#14pmos@35_poly-right vdd vdd p L=0.7U W=3.5U AS=19.469P AD=6.737P PS=25.03U PD=10.325U
Mpmos@36 net@646 net@603 net@659 vdd p L=0.7U W=3.5U AS=2.756P AD=3.369P PS=5.075U PD=5.425U
Mpmos@37 net@659 net@597#8pin@332_polysilicon-1 vdd vdd p L=0.7U W=3.5U AS=19.469P AD=2.756P PS=25.03U PD=5.075U
Mpmos@38 vdd X3#27pmos@38_poly-right net@679 vdd p L=0.7U W=3.5U AS=6.508P AD=19.469P PS=8.75U PD=25.03U
Mpmos@39 net@679 X1#45pin@353_polysilicon-1 vdd vdd p L=0.7U W=3.5U AS=19.469P AD=6.508P PS=25.03U PD=8.75U
Mpmos@40 vdd net@679#2pmos@40_poly-right net@607#3pin@349_polysilicon-1 vdd p L=0.7U W=3.5U AS=6.431P AD=19.469P PS=10.15U PD=25.03U
Mpmos@41 net@679 net@705#3pmos@41_poly-right vdd vdd p L=0.7U W=3.5U AS=19.469P AD=6.508P PS=25.03U PD=8.75U
Mpmos@42 net@738 net@759 vdd vdd p L=0.7U W=3.5U AS=19.469P AD=7.248P PS=25.03U PD=10.85U
Mpmos@43 vdd net@352#32pmos@43_poly-left net@738 vdd p L=0.7U W=3.5U AS=7.248P AD=19.469P PS=10.85U PD=25.03U
Mpmos@44 vdd net@738#7pin@391_polysilicon-1 net@597 vdd p L=0.7U W=3.5U AS=6.431P AD=19.469P PS=10.15U PD=25.03U
Mpmos@45 net@785 net@806 vdd vdd p L=0.7U W=3.5U AS=19.469P AD=7.248P PS=25.03U PD=10.85U
Mpmos@46 vdd X2#45pmos@46_poly-left net@785 vdd p L=0.7U W=3.5U AS=7.248P AD=19.469P PS=10.85U PD=25.03U
Mpmos@47 vdd net@785#7pin@413_polysilicon-1 net@603#4contact@140_metal-1-polysilicon-1 vdd p L=0.7U W=3.5U AS=6.431P AD=19.469P PS=10.15U PD=25.03U
Mpmos@48 net@832 X2#55pmos@48_poly-right vdd vdd p L=0.7U W=3.5U AS=19.469P AD=7.248P PS=25.03U PD=10.85U
Mpmos@49 vdd net@352#42pmos@49_poly-left net@832 vdd p L=0.7U W=3.5U AS=7.248P AD=19.469P PS=10.85U PD=25.03U
Mpmos@50 vdd net@832#7pin@435_polysilicon-1 net@612#10contact@192_metal-1-p-act vdd p L=0.7U W=3.5U AS=6.431P AD=19.469P PS=10.15U PD=25.03U
Mpmos@51 vdd X3#34pmos@51_poly-right net@806#4pin@426_polysilicon-1 vdd p L=0.7U W=3.5U AS=5.972P AD=19.469P PS=9.8U PD=25.03U
Mpmos@52 vdd X3#39pmos@52_poly-right net@759#4pin@404_polysilicon-1 vdd p L=0.7U W=3.5U AS=5.972P AD=19.469P PS=9.8U PD=25.03U
Mpmos@53 vdd X2#64pmos@53_poly-right net@705#6contact@160_metal-1-polysilicon-1 vdd p L=0.7U W=3.5U AS=5.972P AD=19.469P PS=9.8U PD=25.03U
Mpmos@54 vdd X1#55pmos@54_poly-right Y5 vdd p L=0.7U W=3.5U AS=5.972P AD=19.469P PS=9.8U PD=25.03U
Mpmos@55 net@995 X4#52pmos@55_poly-right net@991 vdd p L=0.7U W=3.5U AS=3.369P AD=4.961P PS=5.425U PD=8.12U
Mpmos@56 net@991 net@984#3pmos@56_poly-left net@1004 vdd p L=0.7U W=3.5U AS=3.062P AD=3.369P PS=5.25U PD=5.425U
Mpmos@57 net@1004 net@983#8pmos@57_poly-right net@1024 vdd p L=0.7U W=3.5U AS=3.062P AD=3.062P PS=5.25U PD=5.25U
Mpmos@58 Y6 net@995#5pmos@58_poly-right vdd vdd p L=0.7U W=3.5U AS=19.469P AD=6.737P PS=25.03U PD=10.325U
Mpmos@59 net@1024 net@1008#7pmos@59_poly-right vdd vdd p L=0.7U W=3.5U AS=19.469P AD=3.062P PS=25.03U PD=5.25U
Mpmos@60 net@1068 net@1072 vdd vdd p L=0.7U W=3.5U AS=19.469P AD=7.248P PS=25.03U PD=10.85U
Mpmos@61 vdd net@352#57pin@553_polysilicon-1 net@1068 vdd p L=0.7U W=3.5U AS=7.248P AD=19.469P PS=10.85U PD=25.03U
Mpmos@62 vdd net@1068#9pmos@62_poly-right net@984 vdd p L=0.7U W=3.5U AS=6.431P AD=19.469P PS=10.15U PD=25.03U
Mpmos@63 net@1115 X3#49pmos@63_poly-right vdd vdd p L=0.7U W=3.5U AS=19.469P AD=7.248P PS=25.03U PD=10.85U
Mpmos@64 vdd net@352#67pin@575_polysilicon-1 net@1115 vdd p L=0.7U W=3.5U AS=7.248P AD=19.469P PS=10.85U PD=25.03U
Mpmos@65 vdd net@1115#9pmos@65_poly-right net@983#2contact@228_metal-1-polysilicon-1 vdd p L=0.7U W=3.5U AS=6.431P AD=19.469P PS=10.15U PD=25.03U
Mpmos@66 net@1162 X3#58pmos@66_poly-right vdd vdd p L=0.7U W=3.5U AS=19.469P AD=7.248P PS=25.03U PD=10.85U
Mpmos@67 vdd net@1072#14pin@597_polysilicon-1 net@1162 vdd p L=0.7U W=3.5U AS=7.248P AD=19.469P PS=10.85U PD=25.03U
Mpmos@68 vdd net@1162#9pmos@68_poly-right net@1008#1contact@229_metal-1-polysilicon-1 vdd p L=0.7U W=3.5U AS=6.431P AD=19.469P PS=10.15U PD=25.03U
Mpmos@69 vdd X2#74pmos@69_poly-right net@1072#4pin@571_polysilicon-1 vdd p L=0.7U W=3.5U AS=5.972P AD=19.469P PS=9.8U PD=25.03U
Mpmos@70 net@1252 net@1246#5pmos@70_poly-right net@1248 vdd p L=0.7U W=3.5U AS=3.369P AD=4.961P PS=5.425U PD=8.12U
Mpmos@71 net@1248 X4#60pmos@71_poly-left net@1261 vdd p L=0.7U W=3.5U AS=3.062P AD=3.369P PS=5.25U PD=5.425U
Mpmos@72 net@1261 net@1240#8pmos@72_poly-right net@1281 vdd p L=0.7U W=3.5U AS=3.062P AD=3.062P PS=5.25U PD=5.25U
Mpmos@73 Y7 net@1252#5pmos@73_poly-right vdd vdd p L=0.7U W=3.5U AS=19.469P AD=6.737P PS=25.03U PD=10.325U
Mpmos@74 net@1281 net@1265#7pmos@74_poly-right vdd vdd p L=0.7U W=3.5U AS=19.469P AD=3.062P PS=25.03U PD=5.25U
Mpmos@75 net@1325 X2#79pmos@75_poly-right vdd vdd p L=0.7U W=3.5U AS=19.469P AD=7.248P PS=25.03U PD=10.85U
Mpmos@76 vdd net@352#77pin@686_polysilicon-1 net@1325 vdd p L=0.7U W=3.5U AS=7.248P AD=19.469P PS=10.85U PD=25.03U
Mpmos@77 vdd net@1325#9pmos@77_poly-right net@1240#2contact@285_metal-1-polysilicon-1 vdd p L=0.7U W=3.5U AS=6.431P AD=19.469P PS=10.15U PD=25.03U
Mpmos@78 net@1372 X2#88pmos@78_poly-right vdd vdd p L=0.7U W=3.5U AS=19.469P AD=7.248P PS=25.03U PD=10.85U
Mpmos@79 vdd net@1365#5pin@708_polysilicon-1 net@1372 vdd p L=0.7U W=3.5U AS=7.248P AD=19.469P PS=10.85U PD=25.03U
Mpmos@80 vdd net@1372#9pmos@80_poly-right net@1265#1contact@286_metal-1-polysilicon-1 vdd p L=0.7U W=3.5U AS=6.431P AD=19.469P PS=10.15U PD=25.03U
Mpmos@81 net@1419 net@1423 vdd vdd p L=0.7U W=3.5U AS=19.469P AD=7.248P PS=25.03U PD=10.85U
Mpmos@82 vdd X3#74pin@730_polysilicon-1 net@1419 vdd p L=0.7U W=3.5U AS=7.248P AD=19.469P PS=10.85U PD=25.03U
Mpmos@83 vdd net@1419#9pmos@83_poly-right net@1246 vdd p L=0.7U W=3.5U AS=6.431P AD=19.469P PS=10.15U PD=25.03U
Mpmos@84 vdd X3#79pmos@84_poly-right net@1365 vdd p L=0.7U W=3.5U AS=5.972P AD=19.469P PS=9.8U PD=25.03U
Mpmos@85 vdd X2#97pmos@85_poly-right net@1423#4pin@748_polysilicon-1 vdd p L=0.7U W=3.5U AS=5.972P AD=19.469P PS=9.8U PD=25.03U
** Extracted Parasitic Capacitors ***
C0 net@14 0 10.667fF
C1 net@4#4pin@22_polysilicon-1 0 14.279fF
C2 net@22 0 19.488fF
C3 net@1 0 16.475fF
C4 net@53 0 10.667fF
C5 X3#0contact@17_metal-1-polysilicon-1 0 78.6fF
C6 net@62 0 39.885fF
C7 X1 0 150.92fF
C8 net@103 0 19.374fF
C9 Y1 0 25.425fF
C10 X2#0contact@35_metal-1-polysilicon-1 0 24.321fF
C11 X4#1contact@36_metal-1-polysilicon-1 0 24.048fF
C12 net@22#6contact@39_metal-1-polysilicon-1 0 41.967fF
C13 net@241 0 19.374fF
C14 Y2 0 23.69fF
C15 net@255 0 21.181fF
C16 net@254#1contact@66_metal-1-polysilicon-1 0 20.294fF
C17 net@275#5contact@68_metal-1-polysilicon-1 0 71.749fF
C18 X4#21contact@69_metal-1-polysilicon-1 0 36.608fF
C19 net@325 0 10.667fF
C20 net@367 0 10.667fF
C21 X2#23contact@91_metal-1-polysilicon-1 0 74.707fF
C22 net@321#7contact@92_metal-1-p-act 0 10.241fF
C23 X1#34contact@96_metal-1-polysilicon-1 0 83.693fF
C24 net@352#7contact@97_metal-1-p-act 0 287.989fF
C25 X3#21contact@108_metal-1-polysilicon-1 0 30.123fF
C26 net@275#13pin@236_metal-1 0 42.424fF
C27 Y3 0 30.239fF
C28 net@352#18contact@119_metal-1-polysilicon-1 0 30.282fF
C29 net@517#4contact@122_metal-1-polysilicon-1 0 12.239fF
C30 X2#38contact@123_metal-1-polysilicon-1 0 32.786fF
C31 X4#30contact@124_metal-1-polysilicon-1 0 29.781fF
C32 net@587 0 20.671fF
C33 Y4 0 17.406fF
C34 net@603#4contact@140_metal-1-polysilicon-1 0 14.56fF
C35 net@607#3pin@349_polysilicon-1 0 24.524fF
C36 net@612#7contact@143_metal-1-polysilicon-1 0 26.267fF
C37 X4#33contact@144_metal-1-polysilicon-1 0 46.096fF
C38 net@597 0 21.249fF
C39 net@679 0 11.964fF
C40 X3#23contact@152_metal-1-polysilicon-1 0 61.754fF
C41 X1#41contact@158_metal-1-polysilicon-1 0 65.25fF
C42 net@705#6contact@160_metal-1-polysilicon-1 0 27.299fF
C43 net@738 0 10.667fF
C44 net@759#4pin@404_polysilicon-1 0 12.641fF
C45 net@785 0 10.667fF
C46 net@806#4pin@426_polysilicon-1 0 19.672fF
C47 X2#47contact@184_metal-1-polysilicon-1 0 26.51fF
C48 net@832 0 10.667fF
C49 X2#59pin@448_polysilicon-1 0 21.446fF
C50 net@612#10contact@192_metal-1-p-act 0 19.488fF
C51 X3#37contact@197_metal-1-polysilicon-1 0 47.427fF
C52 X3#42contact@202_metal-1-polysilicon-1 0 49.884fF
C53 X2#67contact@207_metal-1-polysilicon-1 0 40.703fF
C54 X1#58contact@212_metal-1-polysilicon-1 0 41.044fF
C55 Y5 0 15.359fF
C56 net@995 0 19.374fF
C57 Y6 0 19.932fF
C58 net@983#2contact@228_metal-1-polysilicon-1 0 17.563fF
C59 net@1008#1contact@229_metal-1-polysilicon-1 0 18.519fF
C60 net@984 0 42.615fF
C61 X4#46contact@232_metal-1-polysilicon-1 0 64.479fF
C62 net@1068 0 10.667fF
C63 net@1072#4pin@571_polysilicon-1 0 62.998fF
C64 net@1115 0 10.667fF
C65 X3#53pin@593_polysilicon-1 0 19.16fF
C66 net@1162 0 10.667fF
C67 X3#62pin@615_polysilicon-1 0 19.33fF
C68 X2#77contact@269_metal-1-polysilicon-1 0 33.536fF
C69 net@1252 0 19.374fF
C70 Y7 0 18.772fF
C71 net@1240#2contact@285_metal-1-polysilicon-1 0 16.813fF
C72 net@1265#1contact@286_metal-1-polysilicon-1 0 15.72fF
C73 net@1246 0 34.356fF
C74 net@1325 0 10.667fF
C75 X2#83pin@704_polysilicon-1 0 61.822fF
C76 net@1372 0 10.667fF
C77 X2#92pin@726_polysilicon-1 0 70.789fF
C78 net@1365 0 23.643fF
C79 net@1419 0 10.667fF
C80 net@1423#4pin@748_polysilicon-1 0 18.989fF
C81 X3#69contact@325_metal-1-polysilicon-1 0 64.193fF
C82 X2#100contact@331_metal-1-polysilicon-1 0 31.795fF
C83 X2 0 137.851fF
C84 X1#64pin@969_metal-1 0 95.803fF
C85 X2#113pin@981_metal-1 0 390.244fF
C86 X3 0 405.706fF
C87 X4 0 326.733fF
C88 net@4#2nmos@0_poly-right 0 0.17fF
C89 net@1#2nmos@1_poly-left 0 0.173fF
C90 net@14#12nmos@2_poly-left 0 0.128fF
C91 X3#4nmos@3_poly-right 0 0.17fF
C92 X1#2nmos@4_poly-left 0 0.173fF
C93 net@53#12nmos@5_poly-left 0 0.128fF
C94 net@22#10nmos@6_poly-right 0 0.255fF
C95 net@62#10nmos@7_poly-left 0 0.202fF
C96 X2#3nmos@8_poly-left 0 0.213fF
C97 net@103#11nmos@9_poly-left 0 0.196fF
C98 X4#4nmos@10_poly-left 0 0.306fF
C99 X1#12nmos@11_poly-left 0 0.147fF
C100 X3#11nmos@12_poly-left 0 0.167fF
C101 X4#15nmos@13_poly-right 0 0.255fF
C102 net@275 0 0.202fF
C103 net@255#3nmos@15_poly-left 0 0.213fF
C104 net@241#11nmos@16_poly-left 0 0.196fF
C105 net@254#4nmos@17_poly-left 0 0.306fF
C106 net@352#2nmos@18_poly-right 0 0.17fF
C107 net@321 0 0.173fF
C108 net@325#12nmos@20_poly-left 0 0.128fF
C109 X1#26nmos@21_poly-right 0 0.17fF
C110 X2#13nmos@22_poly-left 0 0.173fF
C111 net@367#12nmos@23_poly-left 0 0.128fF
C112 X2#22nmos@24_poly-left 0 0.147fF
C113 X1#33nmos@25_poly-left 0 0.147fF
C114 X3#20nmos@26_poly-left 0 0.147fF
C115 net@352#23nmos@27_poly-right 0 0.183fF
C116 net@275#26nmos@28_poly-left 0 0.177fF
C117 net@517 0 0.167fF
C118 X2#35nmos@30_poly-left 0 0.183fF
C119 X4#29nmos@31_poly-left 0 0.147fF
C120 net@612#5pin@305_polysilicon-1 0 0.137fF
C121 X4#37nmos@33_poly-right 0 0.249fF
C122 net@607 0 0.314fF
C123 net@587#18nmos@35_poly-left 0 0.196fF
C124 net@603#7nmos@36_poly-left 0 0.211fF
C125 net@597#4nmos@37_poly-left 0 0.212fF
C126 X3#26nmos@38_poly-left 0 0.183fF
C127 X1#44nmos@39_poly-left 0 0.173fF
C128 net@679#7nmos@40_poly-left 0 0.128fF
C129 net@705 0 0.105fF
C130 net@759#2nmos@42_poly-right 0 0.17fF
C131 net@352#38nmos@43_poly-left 0 0.173fF
C132 net@738#5nmos@44_poly-left 0 0.128fF
C133 net@806#2nmos@45_poly-right 0 0.17fF
C134 X2#51nmos@46_poly-left 0 0.173fF
C135 net@785#5nmos@47_poly-left 0 0.128fF
C136 X2#57nmos@48_poly-right 0 0.17fF
C137 net@352#48nmos@49_poly-left 0 0.173fF
C138 net@832#5nmos@50_poly-left 0 0.128fF
C139 X3#36nmos@51_poly-left 0 0.147fF
C140 X3#41nmos@52_poly-left 0 0.147fF
C141 X2#66nmos@53_poly-left 0 0.147fF
C142 X1#57nmos@54_poly-left 0 0.147fF
C143 X4#50nmos@55_poly-right 0 0.255fF
C144 net@984#6nmos@56_poly-left 0 0.202fF
C145 net@983#4nmos@57_poly-left 0 0.213fF
C146 net@995#11nmos@58_poly-left 0 0.196fF
C147 net@1008#4nmos@59_poly-left 0 0.306fF
C148 net@1072#2nmos@60_poly-right 0 0.17fF
C149 net@352#56nmos@61_poly-left 0 0.173fF
C150 net@1068#13nmos@62_poly-left 0 0.128fF
C151 X3#51nmos@63_poly-right 0 0.17fF
C152 net@352#66nmos@64_poly-left 0 0.173fF
C153 net@1115#13nmos@65_poly-left 0 0.128fF
C154 X3#60nmos@66_poly-right 0 0.17fF
C155 net@1072#13nmos@67_poly-left 0 0.173fF
C156 net@1162#13nmos@68_poly-left 0 0.128fF
C157 X2#76nmos@69_poly-left 0 0.147fF
C158 net@1246#3nmos@70_poly-right 0 0.255fF
C159 X4#63nmos@71_poly-left 0 0.202fF
C160 net@1240#4nmos@72_poly-left 0 0.213fF
C161 net@1252#11nmos@73_poly-left 0 0.196fF
C162 net@1265#4nmos@74_poly-left 0 0.306fF
C163 X2#81nmos@75_poly-right 0 0.17fF
C164 net@352#76nmos@76_poly-left 0 0.173fF
C165 net@1325#13nmos@77_poly-left 0 0.128fF
C166 X2#90nmos@78_poly-right 0 0.17fF
C167 net@1365#4nmos@79_poly-left 0 0.173fF
C168 net@1372#13nmos@80_poly-left 0 0.128fF
C169 net@1423#2nmos@81_poly-right 0 0.17fF
C170 X3#73nmos@82_poly-left 0 0.173fF
C171 net@1419#13nmos@83_poly-left 0 0.128fF
C172 X3#81nmos@84_poly-left 0 0.147fF
C173 X2#99nmos@85_poly-left 0 0.147fF
C174 net@4#1pin@1_polysilicon-1 0 0.301fF
C175 net@4#6pin@2_polysilicon-1 0 0.222fF
C176 net@1#3pin@3_polysilicon-1 0 0.356fF
C177 net@14#6pmos@2_poly-right 0 0.144fF
C178 net@14#13pin@14_polysilicon-1 0 0.768fF
C179 net@1#6pin@15_polysilicon-1 0 0.34fF
C180 net@4#3pin@21_polysilicon-1 0 0.313fF
C181 X3#3pin@24_polysilicon-1 0 0.301fF
C182 X3#7pin@25_polysilicon-1 0 0.222fF
C183 X1#3pin@26_polysilicon-1 0 0.356fF
C184 net@53#6pmos@5_poly-right 0 0.144fF
C185 net@53#13pin@36_polysilicon-1 0 0.768fF
C186 X1#6pin@37_polysilicon-1 0 0.34fF
C187 X3#5pin@43_polysilicon-1 0 0.313fF
C188 net@103#5pmos@9_poly-right 0 0.201fF
C189 net@103#9pin@47_polysilicon-1 0 0.833fF
C190 net@22#13pin@48_polysilicon-1 0 0.361fF
C191 X2#1pin@52_polysilicon-1 0 0.275fF
C192 X4#0pin@60_polysilicon-1 0 0.262fF
C193 net@62#11pin@63_polysilicon-1 0 0.32fF
C194 net@62#12pin@64_polysilicon-1 0 0.353fF
C195 X2#4pin@66_polysilicon-1 0 0.331fF
C196 X2#5pin@67_polysilicon-1 0 0.275fF
C197 X2#6pin@68_polysilicon-1 0 0.345fF
C198 X4#5pin@69_polysilicon-1 0 0.404fF
C199 X4#6pin@70_polysilicon-1 0 0.334fF
C200 X4#9pin@77_polysilicon-1 0 0.281fF
C201 X4#10pin@78_polysilicon-1 0 0.294fF
C202 X2#9pin@79_polysilicon-1 0 0.347fF
C203 X2#10pin@80_polysilicon-1 0 0.347fF
C204 net@62#9pin@81_polysilicon-1 0 0.301fF
C205 net@62#7pin@83_polysilicon-1 0 0.349fF
C206 net@62#8pin@84_polysilicon-1 0 0.375fF
C207 net@22#7pin@85_polysilicon-1 0 0.301fF
C208 net@22#9pin@87_polysilicon-1 0 0.374fF
C209 net@22#11pin@88_polysilicon-1 0 0.348fF
C210 X2#11pin@90_metal-1 0 61.059fF
C211 X1#11pin@96_polysilicon-1 0 0.748fF
C212 X3#10pin@99_polysilicon-1 0 0.787fF
C213 net@241#5pmos@16_poly-right 0 0.201fF
C214 net@241#9pin@123_polysilicon-1 0 0.833fF
C215 X4#18pin@124_polysilicon-1 0 0.361fF
C216 net@255#1pin@128_polysilicon-1 0 0.275fF
C217 net@254 0 0.262fF
C218 net@275#1pin@139_polysilicon-1 0 0.32fF
C219 net@275#2pin@140_polysilicon-1 0 0.353fF
C220 net@255#4pin@142_polysilicon-1 0 0.331fF
C221 net@255#5pin@143_polysilicon-1 0 0.275fF
C222 net@255#6pin@144_polysilicon-1 0 0.345fF
C223 net@254#5pin@145_polysilicon-1 0 0.404fF
C224 net@254#6pin@146_polysilicon-1 0 0.334fF
C225 net@254#9pin@153_polysilicon-1 0 0.281fF
C226 net@254#10pin@154_polysilicon-1 0 0.294fF
C227 net@255#9pin@155_polysilicon-1 0 0.347fF
C228 net@255#10pin@156_polysilicon-1 0 0.347fF
C229 net@275#6pin@157_polysilicon-1 0 0.301fF
C230 net@275#9pin@158_polysilicon-1 0 0.349fF
C231 net@275#10pin@159_polysilicon-1 0 0.375fF
C232 X4#13pin@160_polysilicon-1 0 0.301fF
C233 X4#14pin@162_polysilicon-1 0 0.374fF
C234 X4#16pin@163_polysilicon-1 0 0.348fF
C235 net@352#1pin@167_polysilicon-1 0 0.301fF
C236 net@352#5pin@168_polysilicon-1 0 0.222fF
C237 net@321#1pin@169_polysilicon-1 0 0.356fF
C238 net@325#6pmos@20_poly-right 0 0.144fF
C239 net@325#13pin@178_polysilicon-1 0 0.768fF
C240 net@321#4pin@179_polysilicon-1 0 0.34fF
C241 net@321#5pin@180_polysilicon-1 0 0.379fF
C242 net@352#3pin@183_polysilicon-1 0 0.313fF
C243 net@352#4pin@184_polysilicon-1 0 0.378fF
C244 X1#25pin@186_polysilicon-1 0 0.301fF
C245 X1#29pin@187_polysilicon-1 0 0.222fF
C246 X2#14pin@188_polysilicon-1 0 0.356fF
C247 net@367#6pmos@23_poly-right 0 0.144fF
C248 net@367#13pin@197_polysilicon-1 0 0.768fF
C249 X2#17pin@198_polysilicon-1 0 0.34fF
C250 X2#18pin@199_polysilicon-1 0 0.379fF
C251 X1#27pin@202_polysilicon-1 0 0.313fF
C252 X1#28pin@203_polysilicon-1 0 0.378fF
C253 X2#21pin@208_polysilicon-1 0 0.748fF
C254 X1#32pin@213_polysilicon-1 0 0.748fF
C255 X4#25pin@233_metal-1 0 59.66fF
C256 X3#19pin@244_polysilicon-1 0 0.748fF
C257 net@275#22pin@251_polysilicon-1 0 0.321fF
C258 X2#33pin@255_polysilicon-1 0 0.275fF
C259 net@275#27pin@256_polysilicon-1 0 0.275fF
C260 net@275#28pin@257_polysilicon-1 0 0.275fF
C261 net@517#1pin@259_polysilicon-1 0 0.245fF
C262 net@517#2pin@260_polysilicon-1 0 0.245fF
C263 X2#36pin@261_polysilicon-1 0 0.258fF
C264 X2#37pin@262_polysilicon-1 0 0.363fF
C265 net@352#22pin@263_polysilicon-1 0 0.291fF
C266 net@352#24pin@269_polysilicon-1 0 0.309fF
C267 net@275#31pin@271_polysilicon-1 0 0.327fF
C268 net@275#32pin@272_polysilicon-1 0 0.379fF
C269 net@517#6pin@274_polysilicon-1 0 0.249fF
C270 net@517#8pin@275_polysilicon-1 0 0.318fF
C271 net@517#9pin@276_polysilicon-1 0 0.305fF
C272 X2#40pin@278_polysilicon-1 0 0.353fF
C273 X2#42pin@279_polysilicon-1 0 0.288fF
C274 net@352#26pin@281_polysilicon-1 0 0.291fF
C275 net@352#27pin@282_polysilicon-1 0 0.278fF
C276 X4#28pin@289_polysilicon-1 0 0.748fF
C277 X2#44pin@295_metal-1 0 56.998fF
C278 X4#32pin@300_metal-1 0 38.328fF
C279 net@587#14pmos@35_poly-right 0 0.201fF
C280 net@587#16pin@303_polysilicon-1 0 0.833fF
C281 net@612#4pin@304_polysilicon-1 0 0.361fF
C282 net@603#5pin@307_polysilicon-1 0 0.275fF
C283 X4#41pin@316_polysilicon-1 0 0.327fF
C284 net@607#6pin@317_polysilicon-1 0 0.366fF
C285 net@607#7pin@318_polysilicon-1 0 0.348fF
C286 net@603#8pin@319_polysilicon-1 0 0.381fF
C287 net@603#9pin@320_polysilicon-1 0 0.353fF
C288 net@603#3pin@321_polysilicon-1 0 0.236fF
C289 net@612#8pin@322_polysilicon-1 0 0.301fF
C290 net@612#2pin@324_polysilicon-1 0 0.366fF
C291 X4#35pin@325_polysilicon-1 0 0.301fF
C292 X4#36pin@327_polysilicon-1 0 0.373fF
C293 X4#42pin@329_polysilicon-1 0 0.262fF
C294 net@597#6pin@330_polysilicon-1 0 0.3fF
C295 net@597#7pin@331_polysilicon-1 0 0.359fF
C296 net@597#8pin@332_polysilicon-1 0 0.157fF
C297 net@597#1pin@338_polysilicon-1 0 0.275fF
C298 net@597#2pin@340_polysilicon-1 0 0.314fF
C299 net@597#5pin@341_polysilicon-1 0 0.506fF
C300 net@603#1pin@342_polysilicon-1 0 0.357fF
C301 net@603#2pin@343_polysilicon-1 0 0.344fF
C302 net@607#1pin@344_polysilicon-1 0 0.331fF
C303 net@607#2pin@345_polysilicon-1 0 0.383fF
C304 X4#38pin@346_polysilicon-1 0 0.399fF
C305 net@612#1pin@348_polysilicon-1 0 0.34fF
C306 X3#25pin@352_polysilicon-1 0 0.255fF
C307 X1#45pin@353_polysilicon-1 0 0.369fF
C308 net@679#2pmos@40_poly-right 0 0.144fF
C309 net@679#8pin@362_polysilicon-1 0 0.768fF
C310 X3#27pmos@38_poly-right 0 0.222fF
C311 X3#29pin@368_polysilicon-1 0 0.321fF
C312 net@705#1pin@369_polysilicon-1 0 0.291fF
C313 net@705#2pin@370_polysilicon-1 0 0.343fF
C314 X1#49pin@375_polysilicon-1 0 0.35fF
C315 X1#50pin@376_polysilicon-1 0 0.403fF
C316 X3#31pin@377_polysilicon-1 0 0.326fF
C317 net@705#4pin@379_polysilicon-1 0 0.449fF
C318 net@705#5pin@380_polysilicon-1 0 0.344fF
C319 net@759#1pin@384_polysilicon-1 0 0.301fF
C320 net@759#6pin@385_polysilicon-1 0 0.222fF
C321 net@352#32pmos@43_poly-left 0 0.356fF
C322 net@738#7pin@391_polysilicon-1 0 0.144fF
C323 net@738#6pin@396_polysilicon-1 0 0.768fF
C324 net@352#33pin@397_polysilicon-1 0 0.34fF
C325 net@759#3pin@403_polysilicon-1 0 0.313fF
C326 net@806#1pin@406_polysilicon-1 0 0.301fF
C327 net@806#6pin@407_polysilicon-1 0 0.222fF
C328 X2#45pmos@46_poly-left 0 0.356fF
C329 net@785#7pin@413_polysilicon-1 0 0.144fF
C330 net@785#6pin@418_polysilicon-1 0 0.768fF
C331 X2#46pin@419_polysilicon-1 0 0.34fF
C332 net@806#3pin@425_polysilicon-1 0 0.313fF
C333 X2#56pin@428_polysilicon-1 0 0.301fF
C334 X2#61pin@429_polysilicon-1 0 0.222fF
C335 net@352#42pmos@49_poly-left 0 0.356fF
C336 net@832#7pin@435_polysilicon-1 0 0.144fF
C337 net@832#6pin@440_polysilicon-1 0 0.768fF
C338 net@352#43pin@441_polysilicon-1 0 0.34fF
C339 X2#58pin@447_polysilicon-1 0 0.313fF
C340 X3#35pin@451_polysilicon-1 0 0.748fF
C341 X3#40pin@458_polysilicon-1 0 0.748fF
C342 X2#65pin@465_polysilicon-1 0 0.748fF
C343 X4#45pin@479_metal-1 0 41.263fF
C344 X2#72pin@494_metal-1 0 41.673fF
C345 X2#73pin@496_metal-1 0 45.188fF
C346 X1#56pin@499_polysilicon-1 0 0.748fF
C347 X1#60pin@505_metal-1 0 61.742fF
C348 net@995#5pmos@58_poly-right 0 0.201fF
C349 net@995#9pin@508_polysilicon-1 0 0.833fF
C350 X4#53pin@509_polysilicon-1 0 0.361fF
C351 net@983#1pin@513_polysilicon-1 0 0.275fF
C352 net@1008 0 0.262fF
C353 net@984#7pin@524_polysilicon-1 0 0.32fF
C354 net@984#8pin@525_polysilicon-1 0 0.353fF
C355 net@983#5pin@527_polysilicon-1 0 0.331fF
C356 net@983#6pin@528_polysilicon-1 0 0.275fF
C357 net@983#7pin@529_polysilicon-1 0 0.345fF
C358 net@1008#5pin@530_polysilicon-1 0 0.404fF
C359 net@1008#6pin@531_polysilicon-1 0 0.334fF
C360 net@1008#9pin@538_polysilicon-1 0 0.281fF
C361 net@1008#10pin@539_polysilicon-1 0 0.294fF
C362 net@983#10pin@540_polysilicon-1 0 0.347fF
C363 net@983 0 0.347fF
C364 net@984#1pin@542_polysilicon-1 0 0.301fF
C365 net@984#4pin@544_polysilicon-1 0 0.349fF
C366 net@984#5pin@545_polysilicon-1 0 0.375fF
C367 X4#47pin@546_polysilicon-1 0 0.301fF
C368 X4#49pin@548_polysilicon-1 0 0.374fF
C369 X4#51pin@549_polysilicon-1 0 0.348fF
C370 net@1072#1pin@551_polysilicon-1 0 0.301fF
C371 net@1072#6pin@552_polysilicon-1 0 0.222fF
C372 net@352#57pin@553_polysilicon-1 0 0.356fF
C373 net@1068#9pmos@62_poly-right 0 0.144fF
C374 net@1068#14pin@563_polysilicon-1 0 0.768fF
C375 net@352#54pin@564_polysilicon-1 0 0.34fF
C376 net@1072#3pin@570_polysilicon-1 0 0.313fF
C377 X3#50pin@573_polysilicon-1 0 0.301fF
C378 X3#55pin@574_polysilicon-1 0 0.222fF
C379 net@352#67pin@575_polysilicon-1 0 0.356fF
C380 net@1115#9pmos@65_poly-right 0 0.144fF
C381 net@1115#14pin@585_polysilicon-1 0 0.768fF
C382 net@352#64pin@586_polysilicon-1 0 0.34fF
C383 X3#52pin@592_polysilicon-1 0 0.313fF
C384 X3#59pin@595_polysilicon-1 0 0.301fF
C385 X3#64pin@596_polysilicon-1 0 0.222fF
C386 net@1072#14pin@597_polysilicon-1 0 0.356fF
C387 net@1162#9pmos@68_poly-right 0 0.144fF
C388 net@1162#14pin@607_polysilicon-1 0 0.768fF
C389 net@1072#11pin@608_polysilicon-1 0 0.34fF
C390 X3#61pin@614_polysilicon-1 0 0.313fF
C391 X2#75pin@624_polysilicon-1 0 0.748fF
C392 X3#67pin@634_metal-1 0 60.513fF
C393 X4#57pin@638_metal-1 0 43.414fF
C394 net@1252#5pmos@73_poly-right 0 0.201fF
C395 net@1252#9pin@641_polysilicon-1 0 0.833fF
C396 net@1246#6pin@642_polysilicon-1 0 0.361fF
C397 net@1240#1pin@646_polysilicon-1 0 0.275fF
C398 net@1265 0 0.262fF
C399 X4#64pin@657_polysilicon-1 0 0.32fF
C400 X4#65pin@658_polysilicon-1 0 0.353fF
C401 net@1240#5pin@660_polysilicon-1 0 0.331fF
C402 net@1240#6pin@661_polysilicon-1 0 0.275fF
C403 net@1240#7pin@662_polysilicon-1 0 0.345fF
C404 net@1265#5pin@663_polysilicon-1 0 0.404fF
C405 net@1265#6pin@664_polysilicon-1 0 0.334fF
C406 net@1265#9pin@671_polysilicon-1 0 0.281fF
C407 net@1265#10pin@672_polysilicon-1 0 0.294fF
C408 net@1240#10pin@673_polysilicon-1 0 0.347fF
C409 net@1240 0 0.347fF
C410 X4#59pin@675_polysilicon-1 0 0.301fF
C411 X4#61pin@677_polysilicon-1 0 0.349fF
C412 X4#62pin@678_polysilicon-1 0 0.375fF
C413 net@1246#1pin@679_polysilicon-1 0 0.301fF
C414 net@1246#2pin@681_polysilicon-1 0 0.374fF
C415 net@1246#4pin@682_polysilicon-1 0 0.348fF
C416 X2#80pin@684_polysilicon-1 0 0.301fF
C417 X2#85pin@685_polysilicon-1 0 0.222fF
C418 net@352#77pin@686_polysilicon-1 0 0.356fF
C419 net@1325#9pmos@77_poly-right 0 0.144fF
C420 net@1325#14pin@696_polysilicon-1 0 0.768fF
C421 net@352#74pin@697_polysilicon-1 0 0.34fF
C422 X2#82pin@703_polysilicon-1 0 0.313fF
C423 X2#89pin@706_polysilicon-1 0 0.301fF
C424 X2#94pin@707_polysilicon-1 0 0.222fF
C425 net@1365#5pin@708_polysilicon-1 0 0.356fF
C426 net@1372#9pmos@80_poly-right 0 0.144fF
C427 net@1372#14pin@718_polysilicon-1 0 0.768fF
C428 net@1365#2pin@719_polysilicon-1 0 0.34fF
C429 X2#91pin@725_polysilicon-1 0 0.313fF
C430 net@1423#1pin@728_polysilicon-1 0 0.301fF
C431 net@1423#6pin@729_polysilicon-1 0 0.222fF
C432 X3#74pin@730_polysilicon-1 0 0.356fF
C433 net@1419#9pmos@83_poly-right 0 0.144fF
C434 net@1419#14pin@740_polysilicon-1 0 0.768fF
C435 X3#71pin@741_polysilicon-1 0 0.34fF
C436 net@1423#3pin@747_polysilicon-1 0 0.313fF
C437 X3#80pin@749_polysilicon-1 0 0.748fF
C438 X2#98pin@754_polysilicon-1 0 0.748fF
C439 X1#67pin@968_metal-1 0 40.752fF
C440 X1#66pin@971_metal-1 0 76.998fF
C441 net@4 0 0.157fF
C442 X3#2pmos@3_poly-right 0 0.157fF
C443 net@22#12pmos@6_poly-right 0 0.224fF
C444 net@62#6pmos@7_poly-left 0 0.314fF
C445 X2#7pmos@8_poly-right 0 0.306fF
C446 X4#7pmos@10_poly-right 0 0.144fF
C447 X1#10pmos@11_poly-right 0 0.137fF
C448 X3#9pmos@12_poly-right 0 0.157fF
C449 X4#17pmos@13_poly-right 0 0.224fF
C450 net@275#4pmos@14_poly-right 0 0.314fF
C451 net@255#7pmos@15_poly-right 0 0.306fF
C452 net@254#7pmos@17_poly-right 0 0.144fF
C453 net@352 0 0.157fF
C454 X1#24pmos@21_poly-right 0 0.157fF
C455 X2#20pmos@24_poly-right 0 0.137fF
C456 X1#31pmos@25_poly-right 0 0.137fF
C457 X3#18pmos@26_poly-right 0 0.137fF
C458 net@352#21pmos@27_poly-right 0 0.186fF
C459 net@517#3pmos@29_poly-right 0 0.271fF
C460 X4#27pmos@31_poly-right 0 0.137fF
C461 net@612 0 0.341fF
C462 X4#40pmos@33_poly-right 0 0.222fF
C463 net@607#8pmos@34_poly-right 0 0.191fF
C464 net@603 0 0.314fF
C465 net@759 0 0.157fF
C466 net@806 0 0.157fF
C467 X2#55pmos@48_poly-right 0 0.157fF
C468 X3#34pmos@51_poly-right 0 0.137fF
C469 X3#39pmos@52_poly-right 0 0.137fF
C470 X2#64pmos@53_poly-right 0 0.137fF
C471 X1#55pmos@54_poly-right 0 0.137fF
C472 X4#52pmos@55_poly-right 0 0.224fF
C473 net@984#3pmos@56_poly-left 0 0.314fF
C474 net@983#8pmos@57_poly-right 0 0.306fF
C475 net@1008#7pmos@59_poly-right 0 0.144fF
C476 net@1072 0 0.157fF
C477 X3#49pmos@63_poly-right 0 0.157fF
C478 X3#58pmos@66_poly-right 0 0.157fF
C479 X2#74pmos@69_poly-right 0 0.137fF
C480 net@1246#5pmos@70_poly-right 0 0.224fF
C481 X4#60pmos@71_poly-left 0 0.314fF
C482 net@1240#8pmos@72_poly-right 0 0.306fF
C483 net@1265#7pmos@74_poly-right 0 0.144fF
C484 X2#79pmos@75_poly-right 0 0.157fF
C485 X2#88pmos@78_poly-right 0 0.157fF
C486 net@1423 0 0.157fF
C487 X3#79pmos@84_poly-right 0 0.137fF
C488 X2#97pmos@85_poly-right 0 0.137fF
** Extracted Parasitic Resistors ***
R0 net@4 net@4##0 7.75
C489 net@4##0 0 0.157fF
R1 net@4##0 net@4##1 7.75
C490 net@4##1 0 0.157fF
R2 net@4##1 net@4##2 7.75
C491 net@4##2 0 0.157fF
R3 net@4##2 net@4#1pin@1_polysilicon-1 7.75
R4 net@4#2nmos@0_poly-right net@4#2nmos@0_poly-right##0 5.425
R5 net@4#2nmos@0_poly-right##0 net@4#3pin@21_polysilicon-1 5.425
R6 net@4#3pin@21_polysilicon-1 net@4#3pin@21_polysilicon-1##0 9.419
C492 net@4#3pin@21_polysilicon-1##0 0 0.221fF
R7 net@4#3pin@21_polysilicon-1##0 net@4#3pin@21_polysilicon-1##1 9.419
C493 net@4#3pin@21_polysilicon-1##1 0 0.221fF
R8 net@4#3pin@21_polysilicon-1##1 net@4#3pin@21_polysilicon-1##2 9.419
C494 net@4#3pin@21_polysilicon-1##2 0 0.221fF
R9 net@4#3pin@21_polysilicon-1##2 net@4#3pin@21_polysilicon-1##3 9.419
C495 net@4#3pin@21_polysilicon-1##3 0 0.221fF
R10 net@4#3pin@21_polysilicon-1##3 net@4#3pin@21_polysilicon-1##4 9.419
C496 net@4#3pin@21_polysilicon-1##4 0 0.221fF
R11 net@4#3pin@21_polysilicon-1##4 net@4#3pin@21_polysilicon-1##5 9.419
C497 net@4#3pin@21_polysilicon-1##5 0 0.221fF
R12 net@4#3pin@21_polysilicon-1##5 net@4#3pin@21_polysilicon-1##6 9.419
C498 net@4#3pin@21_polysilicon-1##6 0 0.221fF
R13 net@4#3pin@21_polysilicon-1##6 net@4#3pin@21_polysilicon-1##7 9.419
C499 net@4#3pin@21_polysilicon-1##7 0 0.221fF
R14 net@4#3pin@21_polysilicon-1##7 net@4#3pin@21_polysilicon-1##8 9.419
C500 net@4#3pin@21_polysilicon-1##8 0 0.221fF
R15 net@4#3pin@21_polysilicon-1##8 net@4#3pin@21_polysilicon-1##9 9.419
C501 net@4#3pin@21_polysilicon-1##9 0 0.221fF
R16 net@4#3pin@21_polysilicon-1##9 net@4#3pin@21_polysilicon-1##10 9.419
C502 net@4#3pin@21_polysilicon-1##10 0 0.221fF
R17 net@4#3pin@21_polysilicon-1##10 net@4#3pin@21_polysilicon-1##11 9.419
C503 net@4#3pin@21_polysilicon-1##11 0 0.221fF
R18 net@4#3pin@21_polysilicon-1##11 net@4#4pin@22_polysilicon-1 9.419
R19 net@4#1pin@1_polysilicon-1 net@4#1pin@1_polysilicon-1##0 8.525
C504 net@4#1pin@1_polysilicon-1##0 0 0.144fF
R20 net@4#1pin@1_polysilicon-1##0 net@4#6pin@2_polysilicon-1 8.525
R21 net@4#6pin@2_polysilicon-1 net@4#2nmos@0_poly-right 6.2
R22 net@1#2nmos@1_poly-left net@1#2nmos@1_poly-left##0 8.525
C505 net@1#2nmos@1_poly-left##0 0 0.173fF
R23 net@1#2nmos@1_poly-left##0 net@1#2nmos@1_poly-left##1 8.525
C506 net@1#2nmos@1_poly-left##1 0 0.173fF
R24 net@1#2nmos@1_poly-left##1 net@1#2nmos@1_poly-left##2 8.525
C507 net@1#2nmos@1_poly-left##2 0 0.173fF
R25 net@1#2nmos@1_poly-left##2 net@1#3pin@3_polysilicon-1 8.525
R26 net@1#6pin@15_polysilicon-1 net@1#6pin@15_polysilicon-1##0 9.92
C508 net@1#6pin@15_polysilicon-1##0 0 0.236fF
R27 net@1#6pin@15_polysilicon-1##0 net@1#6pin@15_polysilicon-1##1 9.92
C509 net@1#6pin@15_polysilicon-1##1 0 0.236fF
R28 net@1#6pin@15_polysilicon-1##1 net@1#6pin@15_polysilicon-1##2 9.92
C510 net@1#6pin@15_polysilicon-1##2 0 0.236fF
R29 net@1#6pin@15_polysilicon-1##2 net@1#6pin@15_polysilicon-1##3 9.92
C511 net@1#6pin@15_polysilicon-1##3 0 0.236fF
R30 net@1#6pin@15_polysilicon-1##3 net@1#6pin@15_polysilicon-1##4 9.92
C512 net@1#6pin@15_polysilicon-1##4 0 0.236fF
R31 net@1#6pin@15_polysilicon-1##4 net@1#6pin@15_polysilicon-1##5 9.92
C513 net@1#6pin@15_polysilicon-1##5 0 0.236fF
R32 net@1#6pin@15_polysilicon-1##5 net@1#6pin@15_polysilicon-1##6 9.92
C514 net@1#6pin@15_polysilicon-1##6 0 0.236fF
R33 net@1#6pin@15_polysilicon-1##6 net@1#6pin@15_polysilicon-1##7 9.92
C515 net@1#6pin@15_polysilicon-1##7 0 0.236fF
R34 net@1#6pin@15_polysilicon-1##7 net@1#6pin@15_polysilicon-1##8 9.92
C516 net@1#6pin@15_polysilicon-1##8 0 0.236fF
R35 net@1#6pin@15_polysilicon-1##8 net@1#6pin@15_polysilicon-1##9 9.92
C517 net@1#6pin@15_polysilicon-1##9 0 0.236fF
R36 net@1#6pin@15_polysilicon-1##9 net@1#6pin@15_polysilicon-1##10 9.92
C518 net@1#6pin@15_polysilicon-1##10 0 0.236fF
R37 net@1#6pin@15_polysilicon-1##10 net@1#6pin@15_polysilicon-1##11 9.92
C519 net@1#6pin@15_polysilicon-1##11 0 0.236fF
R38 net@1#6pin@15_polysilicon-1##11 net@1#6pin@15_polysilicon-1##12 9.92
C520 net@1#6pin@15_polysilicon-1##12 0 0.236fF
R39 net@1#6pin@15_polysilicon-1##12 net@1#6pin@15_polysilicon-1##13 9.92
C521 net@1#6pin@15_polysilicon-1##13 0 0.236fF
R40 net@1#6pin@15_polysilicon-1##13 net@1 9.92
R41 net@14#12nmos@2_poly-left net@14#12nmos@2_poly-left##0 6.717
C522 net@14#12nmos@2_poly-left##0 0 0.128fF
R42 net@14#12nmos@2_poly-left##0 net@14#12nmos@2_poly-left##1 6.717
C523 net@14#12nmos@2_poly-left##1 0 0.128fF
R43 net@14#12nmos@2_poly-left##1 net@14#13pin@14_polysilicon-1 6.717
R44 net@14#13pin@14_polysilicon-1 net@14#13pin@14_polysilicon-1##0 8.525
C524 net@14#13pin@14_polysilicon-1##0 0 0.144fF
R45 net@14#13pin@14_polysilicon-1##0 net@14#6pmos@2_poly-right 8.525
R46 net@14 net@14#13pin@14_polysilicon-1 9.3
R47 net@1#3pin@3_polysilicon-1 net@1#3pin@3_polysilicon-1##0 6.2
C525 net@1#3pin@3_polysilicon-1##0 0 0.105fF
R48 net@1#3pin@3_polysilicon-1##0 net@1#6pin@15_polysilicon-1 6.2
R49 X1#2nmos@4_poly-left X1#2nmos@4_poly-left##0 8.525
C526 X1#2nmos@4_poly-left##0 0 0.173fF
R50 X1#2nmos@4_poly-left##0 X1#2nmos@4_poly-left##1 8.525
C527 X1#2nmos@4_poly-left##1 0 0.173fF
R51 X1#2nmos@4_poly-left##1 X1#2nmos@4_poly-left##2 8.525
C528 X1#2nmos@4_poly-left##2 0 0.173fF
R52 X1#2nmos@4_poly-left##2 X1#3pin@26_polysilicon-1 8.525
R53 X1#6pin@37_polysilicon-1 X1#6pin@37_polysilicon-1##0 9.92
C529 X1#6pin@37_polysilicon-1##0 0 0.236fF
R54 X1#6pin@37_polysilicon-1##0 X1#6pin@37_polysilicon-1##1 9.92
C530 X1#6pin@37_polysilicon-1##1 0 0.236fF
R55 X1#6pin@37_polysilicon-1##1 X1#6pin@37_polysilicon-1##2 9.92
C531 X1#6pin@37_polysilicon-1##2 0 0.236fF
R56 X1#6pin@37_polysilicon-1##2 X1#6pin@37_polysilicon-1##3 9.92
C532 X1#6pin@37_polysilicon-1##3 0 0.236fF
R57 X1#6pin@37_polysilicon-1##3 X1#6pin@37_polysilicon-1##4 9.92
C533 X1#6pin@37_polysilicon-1##4 0 0.236fF
R58 X1#6pin@37_polysilicon-1##4 X1#6pin@37_polysilicon-1##5 9.92
C534 X1#6pin@37_polysilicon-1##5 0 0.236fF
R59 X1#6pin@37_polysilicon-1##5 X1#6pin@37_polysilicon-1##6 9.92
C535 X1#6pin@37_polysilicon-1##6 0 0.236fF
R60 X1#6pin@37_polysilicon-1##6 X1#6pin@37_polysilicon-1##7 9.92
C536 X1#6pin@37_polysilicon-1##7 0 0.236fF
R61 X1#6pin@37_polysilicon-1##7 X1#6pin@37_polysilicon-1##8 9.92
C537 X1#6pin@37_polysilicon-1##8 0 0.236fF
R62 X1#6pin@37_polysilicon-1##8 X1#6pin@37_polysilicon-1##9 9.92
C538 X1#6pin@37_polysilicon-1##9 0 0.236fF
R63 X1#6pin@37_polysilicon-1##9 X1#6pin@37_polysilicon-1##10 9.92
C539 X1#6pin@37_polysilicon-1##10 0 0.236fF
R64 X1#6pin@37_polysilicon-1##10 X1#6pin@37_polysilicon-1##11 9.92
C540 X1#6pin@37_polysilicon-1##11 0 0.236fF
R65 X1#6pin@37_polysilicon-1##11 X1#6pin@37_polysilicon-1##12 9.92
C541 X1#6pin@37_polysilicon-1##12 0 0.236fF
R66 X1#6pin@37_polysilicon-1##12 X1#6pin@37_polysilicon-1##13 9.92
C542 X1#6pin@37_polysilicon-1##13 0 0.236fF
R67 X1#6pin@37_polysilicon-1##13 X1 9.92
R68 net@53#12nmos@5_poly-left net@53#12nmos@5_poly-left##0 6.717
C543 net@53#12nmos@5_poly-left##0 0 0.128fF
R69 net@53#12nmos@5_poly-left##0 net@53#12nmos@5_poly-left##1 6.717
C544 net@53#12nmos@5_poly-left##1 0 0.128fF
R70 net@53#12nmos@5_poly-left##1 net@53#13pin@36_polysilicon-1 6.717
R71 net@53#13pin@36_polysilicon-1 net@53#13pin@36_polysilicon-1##0 8.525
C545 net@53#13pin@36_polysilicon-1##0 0 0.144fF
R72 net@53#13pin@36_polysilicon-1##0 net@53#6pmos@5_poly-right 8.525
R73 net@53 net@53#13pin@36_polysilicon-1 9.3
R74 X3#2pmos@3_poly-right X3#2pmos@3_poly-right##0 7.75
C546 X3#2pmos@3_poly-right##0 0 0.157fF
R75 X3#2pmos@3_poly-right##0 X3#2pmos@3_poly-right##1 7.75
C547 X3#2pmos@3_poly-right##1 0 0.157fF
R76 X3#2pmos@3_poly-right##1 X3#2pmos@3_poly-right##2 7.75
C548 X3#2pmos@3_poly-right##2 0 0.157fF
R77 X3#2pmos@3_poly-right##2 X3#3pin@24_polysilicon-1 7.75
R78 X1#3pin@26_polysilicon-1 X1#3pin@26_polysilicon-1##0 6.2
C549 X1#3pin@26_polysilicon-1##0 0 0.105fF
R79 X1#3pin@26_polysilicon-1##0 X1#6pin@37_polysilicon-1 6.2
R80 X3#4nmos@3_poly-right X3#4nmos@3_poly-right##0 5.425
R81 X3#4nmos@3_poly-right##0 X3#5pin@43_polysilicon-1 5.425
R82 X3#5pin@43_polysilicon-1 X3#5pin@43_polysilicon-1##0 9.419
C550 X3#5pin@43_polysilicon-1##0 0 0.221fF
R83 X3#5pin@43_polysilicon-1##0 X3#5pin@43_polysilicon-1##1 9.419
C551 X3#5pin@43_polysilicon-1##1 0 0.221fF
R84 X3#5pin@43_polysilicon-1##1 X3#5pin@43_polysilicon-1##2 9.419
C552 X3#5pin@43_polysilicon-1##2 0 0.221fF
R85 X3#5pin@43_polysilicon-1##2 X3#5pin@43_polysilicon-1##3 9.419
C553 X3#5pin@43_polysilicon-1##3 0 0.221fF
R86 X3#5pin@43_polysilicon-1##3 X3#5pin@43_polysilicon-1##4 9.419
C554 X3#5pin@43_polysilicon-1##4 0 0.221fF
R87 X3#5pin@43_polysilicon-1##4 X3#5pin@43_polysilicon-1##5 9.419
C555 X3#5pin@43_polysilicon-1##5 0 0.221fF
R88 X3#5pin@43_polysilicon-1##5 X3#5pin@43_polysilicon-1##6 9.419
C556 X3#5pin@43_polysilicon-1##6 0 0.221fF
R89 X3#5pin@43_polysilicon-1##6 X3#5pin@43_polysilicon-1##7 9.419
C557 X3#5pin@43_polysilicon-1##7 0 0.221fF
R90 X3#5pin@43_polysilicon-1##7 X3#5pin@43_polysilicon-1##8 9.419
C558 X3#5pin@43_polysilicon-1##8 0 0.221fF
R91 X3#5pin@43_polysilicon-1##8 X3#5pin@43_polysilicon-1##9 9.419
C559 X3#5pin@43_polysilicon-1##9 0 0.221fF
R92 X3#5pin@43_polysilicon-1##9 X3#5pin@43_polysilicon-1##10 9.419
C560 X3#5pin@43_polysilicon-1##10 0 0.221fF
R93 X3#5pin@43_polysilicon-1##10 X3#5pin@43_polysilicon-1##11 9.419
C561 X3#5pin@43_polysilicon-1##11 0 0.221fF
R94 X3#5pin@43_polysilicon-1##11 X3#0contact@17_metal-1-polysilicon-1 9.419
R95 X3#3pin@24_polysilicon-1 X3#3pin@24_polysilicon-1##0 8.525
C562 X3#3pin@24_polysilicon-1##0 0 0.144fF
R96 X3#3pin@24_polysilicon-1##0 X3#7pin@25_polysilicon-1 8.525
R97 X3#7pin@25_polysilicon-1 X3#4nmos@3_poly-right 6.2
R98 net@62#6pmos@7_poly-left net@62#6pmos@7_poly-left##0 6.975
C563 net@62#6pmos@7_poly-left##0 0 0.118fF
R99 net@62#6pmos@7_poly-left##0 net@62#7pin@83_polysilicon-1 6.975
R100 net@62#7pin@83_polysilicon-1 net@62#7pin@83_polysilicon-1##0 9.688
C564 net@62#7pin@83_polysilicon-1##0 0 0.231fF
R101 net@62#7pin@83_polysilicon-1##0 net@62#7pin@83_polysilicon-1##1 9.688
C565 net@62#7pin@83_polysilicon-1##1 0 0.231fF
R102 net@62#7pin@83_polysilicon-1##1 net@62#7pin@83_polysilicon-1##2 9.688
C566 net@62#7pin@83_polysilicon-1##2 0 0.231fF
R103 net@62#7pin@83_polysilicon-1##2 net@62#7pin@83_polysilicon-1##3 9.688
C567 net@62#7pin@83_polysilicon-1##3 0 0.231fF
R104 net@62#7pin@83_polysilicon-1##3 net@62#7pin@83_polysilicon-1##4 9.688
C568 net@62#7pin@83_polysilicon-1##4 0 0.231fF
R105 net@62#7pin@83_polysilicon-1##4 net@62#7pin@83_polysilicon-1##5 9.688
C569 net@62#7pin@83_polysilicon-1##5 0 0.231fF
R106 net@62#7pin@83_polysilicon-1##5 net@62#7pin@83_polysilicon-1##6 9.688
C570 net@62#7pin@83_polysilicon-1##6 0 0.231fF
R107 net@62#7pin@83_polysilicon-1##6 net@62#7pin@83_polysilicon-1##7 9.688
C571 net@62#7pin@83_polysilicon-1##7 0 0.231fF
R108 net@62#7pin@83_polysilicon-1##7 net@62#7pin@83_polysilicon-1##8 9.688
C572 net@62#7pin@83_polysilicon-1##8 0 0.231fF
R109 net@62#7pin@83_polysilicon-1##8 net@62#7pin@83_polysilicon-1##9 9.688
C573 net@62#7pin@83_polysilicon-1##9 0 0.231fF
R110 net@62#7pin@83_polysilicon-1##9 net@62#7pin@83_polysilicon-1##10 9.688
C574 net@62#7pin@83_polysilicon-1##10 0 0.231fF
R111 net@62#7pin@83_polysilicon-1##10 net@62#7pin@83_polysilicon-1##11 9.688
C575 net@62#7pin@83_polysilicon-1##11 0 0.231fF
R112 net@62#7pin@83_polysilicon-1##11 net@62#7pin@83_polysilicon-1##12 9.688
C576 net@62#7pin@83_polysilicon-1##12 0 0.231fF
R113 net@62#7pin@83_polysilicon-1##12 net@62#7pin@83_polysilicon-1##13 9.688
C577 net@62#7pin@83_polysilicon-1##13 0 0.231fF
R114 net@62#7pin@83_polysilicon-1##13 net@62#7pin@83_polysilicon-1##14 9.688
C578 net@62#7pin@83_polysilicon-1##14 0 0.231fF
R115 net@62#7pin@83_polysilicon-1##14 net@62#8pin@84_polysilicon-1 9.688
R116 net@62#9pin@81_polysilicon-1 net@62#9pin@81_polysilicon-1##0 8.525
C579 net@62#9pin@81_polysilicon-1##0 0 0.144fF
R117 net@62#9pin@81_polysilicon-1##0 net@62#8pin@84_polysilicon-1 8.525
R118 net@22#6contact@39_metal-1-polysilicon-1 net@22#6contact@39_metal-1-polysilicon-1##0 9.3
C580 net@22#6contact@39_metal-1-polysilicon-1##0 0 0.157fF
R119 net@22#6contact@39_metal-1-polysilicon-1##0 net@22#7pin@85_polysilicon-1 9.3
R120 net@22#7pin@85_polysilicon-1 net@22#7pin@85_polysilicon-1##0 8.525
C581 net@22#7pin@85_polysilicon-1##0 0 0.144fF
R121 net@22#7pin@85_polysilicon-1##0 net@22#9pin@87_polysilicon-1 8.525
R122 net@22#10nmos@6_poly-right net@22#10nmos@6_poly-right##0 6.975
C582 net@22#10nmos@6_poly-right##0 0 0.118fF
R123 net@22#10nmos@6_poly-right##0 net@22#11pin@88_polysilicon-1 6.975
R124 net@22#11pin@88_polysilicon-1 net@22#11pin@88_polysilicon-1##0 9.777
C583 net@22#11pin@88_polysilicon-1##0 0 0.23fF
R125 net@22#11pin@88_polysilicon-1##0 net@22#11pin@88_polysilicon-1##1 9.777
C584 net@22#11pin@88_polysilicon-1##1 0 0.23fF
R126 net@22#11pin@88_polysilicon-1##1 net@22#11pin@88_polysilicon-1##2 9.777
C585 net@22#11pin@88_polysilicon-1##2 0 0.23fF
R127 net@22#11pin@88_polysilicon-1##2 net@22#11pin@88_polysilicon-1##3 9.777
C586 net@22#11pin@88_polysilicon-1##3 0 0.23fF
R128 net@22#11pin@88_polysilicon-1##3 net@22#11pin@88_polysilicon-1##4 9.777
C587 net@22#11pin@88_polysilicon-1##4 0 0.23fF
R129 net@22#11pin@88_polysilicon-1##4 net@22#11pin@88_polysilicon-1##5 9.777
C588 net@22#11pin@88_polysilicon-1##5 0 0.23fF
R130 net@22#11pin@88_polysilicon-1##5 net@22#11pin@88_polysilicon-1##6 9.777
C589 net@22#11pin@88_polysilicon-1##6 0 0.23fF
R131 net@22#11pin@88_polysilicon-1##6 net@22#11pin@88_polysilicon-1##7 9.777
C590 net@22#11pin@88_polysilicon-1##7 0 0.23fF
R132 net@22#11pin@88_polysilicon-1##7 net@22#11pin@88_polysilicon-1##8 9.777
C591 net@22#11pin@88_polysilicon-1##8 0 0.23fF
R133 net@22#11pin@88_polysilicon-1##8 net@22#11pin@88_polysilicon-1##9 9.777
C592 net@22#11pin@88_polysilicon-1##9 0 0.23fF
R134 net@22#11pin@88_polysilicon-1##9 net@22#11pin@88_polysilicon-1##10 9.777
C593 net@22#11pin@88_polysilicon-1##10 0 0.23fF
R135 net@22#11pin@88_polysilicon-1##10 net@22#11pin@88_polysilicon-1##11 9.777
C594 net@22#11pin@88_polysilicon-1##11 0 0.23fF
R136 net@22#11pin@88_polysilicon-1##11 net@22#9pin@87_polysilicon-1 9.777
R137 net@22#12pmos@6_poly-right net@22#12pmos@6_poly-right##0 9.817
C595 net@22#12pmos@6_poly-right##0 0 0.224fF
R138 net@22#12pmos@6_poly-right##0 net@22#12pmos@6_poly-right##1 9.817
C596 net@22#12pmos@6_poly-right##1 0 0.224fF
R139 net@22#12pmos@6_poly-right##1 net@22#12pmos@6_poly-right##2 9.817
C597 net@22#12pmos@6_poly-right##2 0 0.224fF
R140 net@22#12pmos@6_poly-right##2 net@22#12pmos@6_poly-right##3 9.817
C598 net@22#12pmos@6_poly-right##3 0 0.224fF
R141 net@22#12pmos@6_poly-right##3 net@22#12pmos@6_poly-right##4 9.817
C599 net@22#12pmos@6_poly-right##4 0 0.224fF
R142 net@22#12pmos@6_poly-right##4 net@22#12pmos@6_poly-right##5 9.817
C600 net@22#12pmos@6_poly-right##5 0 0.224fF
R143 net@22#12pmos@6_poly-right##5 net@22#12pmos@6_poly-right##6 9.817
C601 net@22#12pmos@6_poly-right##6 0 0.224fF
R144 net@22#12pmos@6_poly-right##6 net@22#12pmos@6_poly-right##7 9.817
C602 net@22#12pmos@6_poly-right##7 0 0.224fF
R145 net@22#12pmos@6_poly-right##7 net@22#13pin@48_polysilicon-1 9.817
R146 net@22#13pin@48_polysilicon-1 net@22#13pin@48_polysilicon-1##0 7.233
C603 net@22#13pin@48_polysilicon-1##0 0 0.137fF
R147 net@22#13pin@48_polysilicon-1##0 net@22#13pin@48_polysilicon-1##1 7.233
C604 net@22#13pin@48_polysilicon-1##1 0 0.137fF
R148 net@22#13pin@48_polysilicon-1##1 net@22#10nmos@6_poly-right 7.233
R149 X4#0pin@60_polysilicon-1 X4#0pin@60_polysilicon-1##0 9.3
C605 X4#0pin@60_polysilicon-1##0 0 0.157fF
R150 X4#0pin@60_polysilicon-1##0 X4#1contact@36_metal-1-polysilicon-1 9.3
R151 X2#0contact@35_metal-1-polysilicon-1 X2#0contact@35_metal-1-polysilicon-1##0 9.3
C606 X2#0contact@35_metal-1-polysilicon-1##0 0 0.157fF
R152 X2#0contact@35_metal-1-polysilicon-1##0 X2#1pin@52_polysilicon-1 9.3
R153 net@103#5pmos@9_poly-right net@103#5pmos@9_poly-right##0 8.913
C607 net@103#5pmos@9_poly-right##0 0 0.201fF
R154 net@103#5pmos@9_poly-right##0 net@103#5pmos@9_poly-right##1 8.913
C608 net@103#5pmos@9_poly-right##1 0 0.201fF
R155 net@103#5pmos@9_poly-right##1 net@103#5pmos@9_poly-right##2 8.913
C609 net@103#5pmos@9_poly-right##2 0 0.201fF
R156 net@103#5pmos@9_poly-right##2 net@103#5pmos@9_poly-right##3 8.913
C610 net@103#5pmos@9_poly-right##3 0 0.201fF
R157 net@103#5pmos@9_poly-right##3 net@103#5pmos@9_poly-right##4 8.913
C611 net@103#5pmos@9_poly-right##4 0 0.201fF
R158 net@103#5pmos@9_poly-right##4 net@103#5pmos@9_poly-right##5 8.913
C612 net@103#5pmos@9_poly-right##5 0 0.201fF
R159 net@103#5pmos@9_poly-right##5 net@103#5pmos@9_poly-right##6 8.913
C613 net@103#5pmos@9_poly-right##6 0 0.201fF
R160 net@103#5pmos@9_poly-right##6 net@103#9pin@47_polysilicon-1 8.913
R161 net@103#11nmos@9_poly-left net@103#11nmos@9_poly-left##0 9.688
C614 net@103#11nmos@9_poly-left##0 0 0.196fF
R162 net@103#11nmos@9_poly-left##0 net@103#11nmos@9_poly-left##1 9.688
C615 net@103#11nmos@9_poly-left##1 0 0.196fF
R163 net@103#11nmos@9_poly-left##1 net@103#11nmos@9_poly-left##2 9.688
C616 net@103#11nmos@9_poly-left##2 0 0.196fF
R164 net@103#11nmos@9_poly-left##2 net@103#9pin@47_polysilicon-1 9.688
R165 net@103 net@103#9pin@47_polysilicon-1 7.44
R166 net@62#10nmos@7_poly-left net@62#10nmos@7_poly-left##0 9.3
C617 net@62#10nmos@7_poly-left##0 0 0.202fF
R167 net@62#10nmos@7_poly-left##0 net@62#10nmos@7_poly-left##1 9.3
C618 net@62#10nmos@7_poly-left##1 0 0.202fF
R168 net@62#10nmos@7_poly-left##1 net@62#10nmos@7_poly-left##2 9.3
C619 net@62#10nmos@7_poly-left##2 0 0.202fF
R169 net@62#10nmos@7_poly-left##2 net@62#10nmos@7_poly-left##3 9.3
C620 net@62#10nmos@7_poly-left##3 0 0.202fF
R170 net@62#10nmos@7_poly-left##3 net@62#10nmos@7_poly-left##4 9.3
C621 net@62#10nmos@7_poly-left##4 0 0.202fF
R171 net@62#10nmos@7_poly-left##4 net@62#11pin@63_polysilicon-1 9.3
R172 net@62#11pin@63_polysilicon-1 net@62#11pin@63_polysilicon-1##0 6.975
C622 net@62#11pin@63_polysilicon-1##0 0 0.118fF
R173 net@62#11pin@63_polysilicon-1##0 net@62#12pin@64_polysilicon-1 6.975
R174 net@62#6pmos@7_poly-left net@62#6pmos@7_poly-left##0 9.042
C623 net@62#6pmos@7_poly-left##0 0 0.196fF
R175 net@62#6pmos@7_poly-left##0 net@62#6pmos@7_poly-left##1 9.042
C624 net@62#6pmos@7_poly-left##1 0 0.196fF
R176 net@62#6pmos@7_poly-left##1 net@62#6pmos@7_poly-left##2 9.042
C625 net@62#6pmos@7_poly-left##2 0 0.196fF
R177 net@62#6pmos@7_poly-left##2 net@62#6pmos@7_poly-left##3 9.042
C626 net@62#6pmos@7_poly-left##3 0 0.196fF
R178 net@62#6pmos@7_poly-left##3 net@62#6pmos@7_poly-left##4 9.042
C627 net@62#6pmos@7_poly-left##4 0 0.196fF
R179 net@62#6pmos@7_poly-left##4 net@62#12pin@64_polysilicon-1 9.042
R180 X2#3nmos@8_poly-left X2#3nmos@8_poly-left##0 9.817
C628 X2#3nmos@8_poly-left##0 0 0.213fF
R181 X2#3nmos@8_poly-left##0 X2#3nmos@8_poly-left##1 9.817
C629 X2#3nmos@8_poly-left##1 0 0.213fF
R182 X2#3nmos@8_poly-left##1 X2#3nmos@8_poly-left##2 9.817
C630 X2#3nmos@8_poly-left##2 0 0.213fF
R183 X2#3nmos@8_poly-left##2 X2#3nmos@8_poly-left##3 9.817
C631 X2#3nmos@8_poly-left##3 0 0.213fF
R184 X2#3nmos@8_poly-left##3 X2#3nmos@8_poly-left##4 9.817
C632 X2#3nmos@8_poly-left##4 0 0.213fF
R185 X2#3nmos@8_poly-left##4 X2#4pin@66_polysilicon-1 9.817
R186 X2#4pin@66_polysilicon-1 X2#4pin@66_polysilicon-1##0 6.975
C633 X2#4pin@66_polysilicon-1##0 0 0.118fF
R187 X2#4pin@66_polysilicon-1##0 X2#5pin@67_polysilicon-1 6.975
R188 X2#5pin@67_polysilicon-1 X2#5pin@67_polysilicon-1##0 7.75
C634 X2#5pin@67_polysilicon-1##0 0 0.157fF
R189 X2#5pin@67_polysilicon-1##0 X2#5pin@67_polysilicon-1##1 7.75
C635 X2#5pin@67_polysilicon-1##1 0 0.157fF
R190 X2#5pin@67_polysilicon-1##1 X2#5pin@67_polysilicon-1##2 7.75
C636 X2#5pin@67_polysilicon-1##2 0 0.157fF
R191 X2#5pin@67_polysilicon-1##2 X2#6pin@68_polysilicon-1 7.75
R192 X2#6pin@68_polysilicon-1 X2#6pin@68_polysilicon-1##0 9.3
C637 X2#6pin@68_polysilicon-1##0 0 0.188fF
R193 X2#6pin@68_polysilicon-1##0 X2#6pin@68_polysilicon-1##1 9.3
C638 X2#6pin@68_polysilicon-1##1 0 0.188fF
R194 X2#6pin@68_polysilicon-1##1 X2#6pin@68_polysilicon-1##2 9.3
C639 X2#6pin@68_polysilicon-1##2 0 0.188fF
R195 X2#6pin@68_polysilicon-1##2 X2#7pmos@8_poly-right 9.3
R196 X4#4nmos@10_poly-left X4#4nmos@10_poly-left##0 9.3
C640 X4#4nmos@10_poly-left##0 0 0.214fF
R197 X4#4nmos@10_poly-left##0 X4#4nmos@10_poly-left##1 9.3
C641 X4#4nmos@10_poly-left##1 0 0.214fF
R198 X4#4nmos@10_poly-left##1 X4#4nmos@10_poly-left##2 9.3
C642 X4#4nmos@10_poly-left##2 0 0.214fF
R199 X4#4nmos@10_poly-left##2 X4#4nmos@10_poly-left##3 9.3
C643 X4#4nmos@10_poly-left##3 0 0.214fF
R200 X4#4nmos@10_poly-left##3 X4#4nmos@10_poly-left##4 9.3
C644 X4#4nmos@10_poly-left##4 0 0.214fF
R201 X4#4nmos@10_poly-left##4 X4#4nmos@10_poly-left##5 9.3
C645 X4#4nmos@10_poly-left##5 0 0.214fF
R202 X4#4nmos@10_poly-left##5 X4#4nmos@10_poly-left##6 9.3
C646 X4#4nmos@10_poly-left##6 0 0.214fF
R203 X4#4nmos@10_poly-left##6 X4#4nmos@10_poly-left##7 9.3
C647 X4#4nmos@10_poly-left##7 0 0.214fF
R204 X4#4nmos@10_poly-left##7 X4#4nmos@10_poly-left##8 9.3
C648 X4#4nmos@10_poly-left##8 0 0.214fF
R205 X4#4nmos@10_poly-left##8 X4#5pin@69_polysilicon-1 9.3
R206 X4#5pin@69_polysilicon-1 X4#5pin@69_polysilicon-1##0 8.99
C649 X4#5pin@69_polysilicon-1##0 0 0.19fF
R207 X4#5pin@69_polysilicon-1##0 X4#5pin@69_polysilicon-1##1 8.99
C650 X4#5pin@69_polysilicon-1##1 0 0.19fF
R208 X4#5pin@69_polysilicon-1##1 X4#5pin@69_polysilicon-1##2 8.99
C651 X4#5pin@69_polysilicon-1##2 0 0.19fF
R209 X4#5pin@69_polysilicon-1##2 X4#5pin@69_polysilicon-1##3 8.99
C652 X4#5pin@69_polysilicon-1##3 0 0.19fF
R210 X4#5pin@69_polysilicon-1##3 X4#6pin@70_polysilicon-1 8.99
R211 X4#6pin@70_polysilicon-1 X4#6pin@70_polysilicon-1##0 8.525
C653 X4#6pin@70_polysilicon-1##0 0 0.144fF
R212 X4#6pin@70_polysilicon-1##0 X4#7pmos@10_poly-right 8.525
R213 X4#4nmos@10_poly-left X4#4nmos@10_poly-left##0 5.425
R214 X4#4nmos@10_poly-left##0 X4#9pin@77_polysilicon-1 5.425
R215 X4#9pin@77_polysilicon-1 X4#9pin@77_polysilicon-1##0 8.99
C654 X4#9pin@77_polysilicon-1##0 0 0.19fF
R216 X4#9pin@77_polysilicon-1##0 X4#9pin@77_polysilicon-1##1 8.99
C655 X4#9pin@77_polysilicon-1##1 0 0.19fF
R217 X4#9pin@77_polysilicon-1##1 X4#9pin@77_polysilicon-1##2 8.99
C656 X4#9pin@77_polysilicon-1##2 0 0.19fF
R218 X4#9pin@77_polysilicon-1##2 X4#9pin@77_polysilicon-1##3 8.99
C657 X4#9pin@77_polysilicon-1##3 0 0.19fF
R219 X4#9pin@77_polysilicon-1##3 X4#10pin@78_polysilicon-1 8.99
R220 X4#10pin@78_polysilicon-1 X4#10pin@78_polysilicon-1##0 6.2
C658 X4#10pin@78_polysilicon-1##0 0 0.105fF
R221 X4#10pin@78_polysilicon-1##0 X4#0pin@60_polysilicon-1 6.2
R222 X2#7pmos@8_poly-right X2#7pmos@8_poly-right##0 6.975
C659 X2#7pmos@8_poly-right##0 0 0.118fF
R223 X2#7pmos@8_poly-right##0 X2#9pin@79_polysilicon-1 6.975
R224 X2#9pin@79_polysilicon-1 X2#9pin@79_polysilicon-1##0 9.864
C660 X2#9pin@79_polysilicon-1##0 0 0.229fF
R225 X2#9pin@79_polysilicon-1##0 X2#9pin@79_polysilicon-1##1 9.864
C661 X2#9pin@79_polysilicon-1##1 0 0.229fF
R226 X2#9pin@79_polysilicon-1##1 X2#9pin@79_polysilicon-1##2 9.864
C662 X2#9pin@79_polysilicon-1##2 0 0.229fF
R227 X2#9pin@79_polysilicon-1##2 X2#9pin@79_polysilicon-1##3 9.864
C663 X2#9pin@79_polysilicon-1##3 0 0.229fF
R228 X2#9pin@79_polysilicon-1##3 X2#9pin@79_polysilicon-1##4 9.864
C664 X2#9pin@79_polysilicon-1##4 0 0.229fF
R229 X2#9pin@79_polysilicon-1##4 X2#9pin@79_polysilicon-1##5 9.864
C665 X2#9pin@79_polysilicon-1##5 0 0.229fF
R230 X2#9pin@79_polysilicon-1##5 X2#9pin@79_polysilicon-1##6 9.864
C666 X2#9pin@79_polysilicon-1##6 0 0.229fF
R231 X2#9pin@79_polysilicon-1##6 X2#9pin@79_polysilicon-1##7 9.864
C667 X2#9pin@79_polysilicon-1##7 0 0.229fF
R232 X2#9pin@79_polysilicon-1##7 X2#9pin@79_polysilicon-1##8 9.864
C668 X2#9pin@79_polysilicon-1##8 0 0.229fF
R233 X2#9pin@79_polysilicon-1##8 X2#9pin@79_polysilicon-1##9 9.864
C669 X2#9pin@79_polysilicon-1##9 0 0.229fF
R234 X2#9pin@79_polysilicon-1##9 X2#10pin@80_polysilicon-1 9.864
R235 X2#10pin@80_polysilicon-1 X2#1pin@52_polysilicon-1 9.3
R236 net@62 net@62##0 9.3
C670 net@62##0 0 0.157fF
R237 net@62##0 net@62#9pin@81_polysilicon-1 9.3
R238 X4#1contact@36_metal-1-polysilicon-1 X4 6.104
R239 X2#0contact@35_metal-1-polysilicon-1 X2#11pin@90_metal-1 6.104
R240 net@22 net@22#6contact@39_metal-1-polysilicon-1 4.124
R241 X1#10pmos@11_poly-right X1#10pmos@11_poly-right##0 7.233
C671 X1#10pmos@11_poly-right##0 0 0.137fF
R242 X1#10pmos@11_poly-right##0 X1#10pmos@11_poly-right##1 7.233
C672 X1#10pmos@11_poly-right##1 0 0.137fF
R243 X1#10pmos@11_poly-right##1 X1#11pin@96_polysilicon-1 7.233
R244 X1#11pin@96_polysilicon-1 X1#11pin@96_polysilicon-1##0 7.75
C673 X1#11pin@96_polysilicon-1##0 0 0.147fF
R245 X1#11pin@96_polysilicon-1##0 X1#11pin@96_polysilicon-1##1 7.75
C674 X1#11pin@96_polysilicon-1##1 0 0.147fF
R246 X1#11pin@96_polysilicon-1##1 X1#12nmos@11_poly-left 7.75
R247 X1 X1#11pin@96_polysilicon-1 8.68
R248 X3#9pmos@12_poly-right X3#9pmos@12_poly-right##0 9.3
C675 X3#9pmos@12_poly-right##0 0 0.157fF
R249 X3#9pmos@12_poly-right##0 X3#10pin@99_polysilicon-1 9.3
R250 X3#10pin@99_polysilicon-1 X3#10pin@99_polysilicon-1##0 8.783
C676 X3#10pin@99_polysilicon-1##0 0 0.167fF
R251 X3#10pin@99_polysilicon-1##0 X3#10pin@99_polysilicon-1##1 8.783
C677 X3#10pin@99_polysilicon-1##1 0 0.167fF
R252 X3#10pin@99_polysilicon-1##1 X3#11nmos@12_poly-left 8.783
R253 X3#0contact@17_metal-1-polysilicon-1 X3#10pin@99_polysilicon-1 8.68
R254 X4#13pin@160_polysilicon-1 X4#13pin@160_polysilicon-1##0 8.525
C678 X4#13pin@160_polysilicon-1##0 0 0.144fF
R255 X4#13pin@160_polysilicon-1##0 X4#14pin@162_polysilicon-1 8.525
R256 X4#15nmos@13_poly-right X4#15nmos@13_poly-right##0 6.975
C679 X4#15nmos@13_poly-right##0 0 0.118fF
R257 X4#15nmos@13_poly-right##0 X4#16pin@163_polysilicon-1 6.975
R258 X4#16pin@163_polysilicon-1 X4#16pin@163_polysilicon-1##0 9.777
C680 X4#16pin@163_polysilicon-1##0 0 0.23fF
R259 X4#16pin@163_polysilicon-1##0 X4#16pin@163_polysilicon-1##1 9.777
C681 X4#16pin@163_polysilicon-1##1 0 0.23fF
R260 X4#16pin@163_polysilicon-1##1 X4#16pin@163_polysilicon-1##2 9.777
C682 X4#16pin@163_polysilicon-1##2 0 0.23fF
R261 X4#16pin@163_polysilicon-1##2 X4#16pin@163_polysilicon-1##3 9.777
C683 X4#16pin@163_polysilicon-1##3 0 0.23fF
R262 X4#16pin@163_polysilicon-1##3 X4#16pin@163_polysilicon-1##4 9.777
C684 X4#16pin@163_polysilicon-1##4 0 0.23fF
R263 X4#16pin@163_polysilicon-1##4 X4#16pin@163_polysilicon-1##5 9.777
C685 X4#16pin@163_polysilicon-1##5 0 0.23fF
R264 X4#16pin@163_polysilicon-1##5 X4#16pin@163_polysilicon-1##6 9.777
C686 X4#16pin@163_polysilicon-1##6 0 0.23fF
R265 X4#16pin@163_polysilicon-1##6 X4#16pin@163_polysilicon-1##7 9.777
C687 X4#16pin@163_polysilicon-1##7 0 0.23fF
R266 X4#16pin@163_polysilicon-1##7 X4#16pin@163_polysilicon-1##8 9.777
C688 X4#16pin@163_polysilicon-1##8 0 0.23fF
R267 X4#16pin@163_polysilicon-1##8 X4#16pin@163_polysilicon-1##9 9.777
C689 X4#16pin@163_polysilicon-1##9 0 0.23fF
R268 X4#16pin@163_polysilicon-1##9 X4#16pin@163_polysilicon-1##10 9.777
C690 X4#16pin@163_polysilicon-1##10 0 0.23fF
R269 X4#16pin@163_polysilicon-1##10 X4#16pin@163_polysilicon-1##11 9.777
C691 X4#16pin@163_polysilicon-1##11 0 0.23fF
R270 X4#16pin@163_polysilicon-1##11 X4#14pin@162_polysilicon-1 9.777
R271 X4#17pmos@13_poly-right X4#17pmos@13_poly-right##0 9.817
C692 X4#17pmos@13_poly-right##0 0 0.224fF
R272 X4#17pmos@13_poly-right##0 X4#17pmos@13_poly-right##1 9.817
C693 X4#17pmos@13_poly-right##1 0 0.224fF
R273 X4#17pmos@13_poly-right##1 X4#17pmos@13_poly-right##2 9.817
C694 X4#17pmos@13_poly-right##2 0 0.224fF
R274 X4#17pmos@13_poly-right##2 X4#17pmos@13_poly-right##3 9.817
C695 X4#17pmos@13_poly-right##3 0 0.224fF
R275 X4#17pmos@13_poly-right##3 X4#17pmos@13_poly-right##4 9.817
C696 X4#17pmos@13_poly-right##4 0 0.224fF
R276 X4#17pmos@13_poly-right##4 X4#17pmos@13_poly-right##5 9.817
C697 X4#17pmos@13_poly-right##5 0 0.224fF
R277 X4#17pmos@13_poly-right##5 X4#17pmos@13_poly-right##6 9.817
C698 X4#17pmos@13_poly-right##6 0 0.224fF
R278 X4#17pmos@13_poly-right##6 X4#17pmos@13_poly-right##7 9.817
C699 X4#17pmos@13_poly-right##7 0 0.224fF
R279 X4#17pmos@13_poly-right##7 X4#18pin@124_polysilicon-1 9.817
R280 X4#18pin@124_polysilicon-1 X4#18pin@124_polysilicon-1##0 7.233
C700 X4#18pin@124_polysilicon-1##0 0 0.137fF
R281 X4#18pin@124_polysilicon-1##0 X4#18pin@124_polysilicon-1##1 7.233
C701 X4#18pin@124_polysilicon-1##1 0 0.137fF
R282 X4#18pin@124_polysilicon-1##1 X4#15nmos@13_poly-right 7.233
R283 net@254 net@254##0 9.3
C702 net@254##0 0 0.157fF
R284 net@254##0 net@254#1contact@66_metal-1-polysilicon-1 9.3
R285 net@255 net@255##0 9.3
C703 net@255##0 0 0.157fF
R286 net@255##0 net@255#1pin@128_polysilicon-1 9.3
R287 net@241#5pmos@16_poly-right net@241#5pmos@16_poly-right##0 8.913
C704 net@241#5pmos@16_poly-right##0 0 0.201fF
R288 net@241#5pmos@16_poly-right##0 net@241#5pmos@16_poly-right##1 8.913
C705 net@241#5pmos@16_poly-right##1 0 0.201fF
R289 net@241#5pmos@16_poly-right##1 net@241#5pmos@16_poly-right##2 8.913
C706 net@241#5pmos@16_poly-right##2 0 0.201fF
R290 net@241#5pmos@16_poly-right##2 net@241#5pmos@16_poly-right##3 8.913
C707 net@241#5pmos@16_poly-right##3 0 0.201fF
R291 net@241#5pmos@16_poly-right##3 net@241#5pmos@16_poly-right##4 8.913
C708 net@241#5pmos@16_poly-right##4 0 0.201fF
R292 net@241#5pmos@16_poly-right##4 net@241#5pmos@16_poly-right##5 8.913
C709 net@241#5pmos@16_poly-right##5 0 0.201fF
R293 net@241#5pmos@16_poly-right##5 net@241#5pmos@16_poly-right##6 8.913
C710 net@241#5pmos@16_poly-right##6 0 0.201fF
R294 net@241#5pmos@16_poly-right##6 net@241#9pin@123_polysilicon-1 8.913
R295 net@241#11nmos@16_poly-left net@241#11nmos@16_poly-left##0 9.688
C711 net@241#11nmos@16_poly-left##0 0 0.196fF
R296 net@241#11nmos@16_poly-left##0 net@241#11nmos@16_poly-left##1 9.688
C712 net@241#11nmos@16_poly-left##1 0 0.196fF
R297 net@241#11nmos@16_poly-left##1 net@241#11nmos@16_poly-left##2 9.688
C713 net@241#11nmos@16_poly-left##2 0 0.196fF
R298 net@241#11nmos@16_poly-left##2 net@241#9pin@123_polysilicon-1 9.688
R299 net@241 net@241#9pin@123_polysilicon-1 7.44
R300 net@275 net@275##0 9.3
C714 net@275##0 0 0.202fF
R301 net@275##0 net@275##1 9.3
C715 net@275##1 0 0.202fF
R302 net@275##1 net@275##2 9.3
C716 net@275##2 0 0.202fF
R303 net@275##2 net@275##3 9.3
C717 net@275##3 0 0.202fF
R304 net@275##3 net@275##4 9.3
C718 net@275##4 0 0.202fF
R305 net@275##4 net@275#1pin@139_polysilicon-1 9.3
R306 net@275#1pin@139_polysilicon-1 net@275#1pin@139_polysilicon-1##0 6.975
C719 net@275#1pin@139_polysilicon-1##0 0 0.118fF
R307 net@275#1pin@139_polysilicon-1##0 net@275#2pin@140_polysilicon-1 6.975
R308 net@275#4pmos@14_poly-right net@275#4pmos@14_poly-right##0 9.042
C720 net@275#4pmos@14_poly-right##0 0 0.196fF
R309 net@275#4pmos@14_poly-right##0 net@275#4pmos@14_poly-right##1 9.042
C721 net@275#4pmos@14_poly-right##1 0 0.196fF
R310 net@275#4pmos@14_poly-right##1 net@275#4pmos@14_poly-right##2 9.042
C722 net@275#4pmos@14_poly-right##2 0 0.196fF
R311 net@275#4pmos@14_poly-right##2 net@275#4pmos@14_poly-right##3 9.042
C723 net@275#4pmos@14_poly-right##3 0 0.196fF
R312 net@275#4pmos@14_poly-right##3 net@275#4pmos@14_poly-right##4 9.042
C724 net@275#4pmos@14_poly-right##4 0 0.196fF
R313 net@275#4pmos@14_poly-right##4 net@275#2pin@140_polysilicon-1 9.042
R314 net@255#3nmos@15_poly-left net@255#3nmos@15_poly-left##0 9.817
C725 net@255#3nmos@15_poly-left##0 0 0.213fF
R315 net@255#3nmos@15_poly-left##0 net@255#3nmos@15_poly-left##1 9.817
C726 net@255#3nmos@15_poly-left##1 0 0.213fF
R316 net@255#3nmos@15_poly-left##1 net@255#3nmos@15_poly-left##2 9.817
C727 net@255#3nmos@15_poly-left##2 0 0.213fF
R317 net@255#3nmos@15_poly-left##2 net@255#3nmos@15_poly-left##3 9.817
C728 net@255#3nmos@15_poly-left##3 0 0.213fF
R318 net@255#3nmos@15_poly-left##3 net@255#3nmos@15_poly-left##4 9.817
C729 net@255#3nmos@15_poly-left##4 0 0.213fF
R319 net@255#3nmos@15_poly-left##4 net@255#4pin@142_polysilicon-1 9.817
R320 net@255#4pin@142_polysilicon-1 net@255#4pin@142_polysilicon-1##0 6.975
C730 net@255#4pin@142_polysilicon-1##0 0 0.118fF
R321 net@255#4pin@142_polysilicon-1##0 net@255#5pin@143_polysilicon-1 6.975
R322 net@255#5pin@143_polysilicon-1 net@255#5pin@143_polysilicon-1##0 7.75
C731 net@255#5pin@143_polysilicon-1##0 0 0.157fF
R323 net@255#5pin@143_polysilicon-1##0 net@255#5pin@143_polysilicon-1##1 7.75
C732 net@255#5pin@143_polysilicon-1##1 0 0.157fF
R324 net@255#5pin@143_polysilicon-1##1 net@255#5pin@143_polysilicon-1##2 7.75
C733 net@255#5pin@143_polysilicon-1##2 0 0.157fF
R325 net@255#5pin@143_polysilicon-1##2 net@255#6pin@144_polysilicon-1 7.75
R326 net@255#6pin@144_polysilicon-1 net@255#6pin@144_polysilicon-1##0 9.3
C734 net@255#6pin@144_polysilicon-1##0 0 0.188fF
R327 net@255#6pin@144_polysilicon-1##0 net@255#6pin@144_polysilicon-1##1 9.3
C735 net@255#6pin@144_polysilicon-1##1 0 0.188fF
R328 net@255#6pin@144_polysilicon-1##1 net@255#6pin@144_polysilicon-1##2 9.3
C736 net@255#6pin@144_polysilicon-1##2 0 0.188fF
R329 net@255#6pin@144_polysilicon-1##2 net@255#7pmos@15_poly-right 9.3
R330 net@254#4nmos@17_poly-left net@254#4nmos@17_poly-left##0 9.3
C737 net@254#4nmos@17_poly-left##0 0 0.214fF
R331 net@254#4nmos@17_poly-left##0 net@254#4nmos@17_poly-left##1 9.3
C738 net@254#4nmos@17_poly-left##1 0 0.214fF
R332 net@254#4nmos@17_poly-left##1 net@254#4nmos@17_poly-left##2 9.3
C739 net@254#4nmos@17_poly-left##2 0 0.214fF
R333 net@254#4nmos@17_poly-left##2 net@254#4nmos@17_poly-left##3 9.3
C740 net@254#4nmos@17_poly-left##3 0 0.214fF
R334 net@254#4nmos@17_poly-left##3 net@254#4nmos@17_poly-left##4 9.3
C741 net@254#4nmos@17_poly-left##4 0 0.214fF
R335 net@254#4nmos@17_poly-left##4 net@254#4nmos@17_poly-left##5 9.3
C742 net@254#4nmos@17_poly-left##5 0 0.214fF
R336 net@254#4nmos@17_poly-left##5 net@254#4nmos@17_poly-left##6 9.3
C743 net@254#4nmos@17_poly-left##6 0 0.214fF
R337 net@254#4nmos@17_poly-left##6 net@254#4nmos@17_poly-left##7 9.3
C744 net@254#4nmos@17_poly-left##7 0 0.214fF
R338 net@254#4nmos@17_poly-left##7 net@254#4nmos@17_poly-left##8 9.3
C745 net@254#4nmos@17_poly-left##8 0 0.214fF
R339 net@254#4nmos@17_poly-left##8 net@254#5pin@145_polysilicon-1 9.3
R340 net@254#5pin@145_polysilicon-1 net@254#5pin@145_polysilicon-1##0 8.99
C746 net@254#5pin@145_polysilicon-1##0 0 0.19fF
R341 net@254#5pin@145_polysilicon-1##0 net@254#5pin@145_polysilicon-1##1 8.99
C747 net@254#5pin@145_polysilicon-1##1 0 0.19fF
R342 net@254#5pin@145_polysilicon-1##1 net@254#5pin@145_polysilicon-1##2 8.99
C748 net@254#5pin@145_polysilicon-1##2 0 0.19fF
R343 net@254#5pin@145_polysilicon-1##2 net@254#5pin@145_polysilicon-1##3 8.99
C749 net@254#5pin@145_polysilicon-1##3 0 0.19fF
R344 net@254#5pin@145_polysilicon-1##3 net@254#6pin@146_polysilicon-1 8.99
R345 net@254#6pin@146_polysilicon-1 net@254#6pin@146_polysilicon-1##0 8.525
C750 net@254#6pin@146_polysilicon-1##0 0 0.144fF
R346 net@254#6pin@146_polysilicon-1##0 net@254#7pmos@17_poly-right 8.525
R347 net@254#4nmos@17_poly-left net@254#4nmos@17_poly-left##0 5.425
R348 net@254#4nmos@17_poly-left##0 net@254#9pin@153_polysilicon-1 5.425
R349 net@254#9pin@153_polysilicon-1 net@254#9pin@153_polysilicon-1##0 8.99
C751 net@254#9pin@153_polysilicon-1##0 0 0.19fF
R350 net@254#9pin@153_polysilicon-1##0 net@254#9pin@153_polysilicon-1##1 8.99
C752 net@254#9pin@153_polysilicon-1##1 0 0.19fF
R351 net@254#9pin@153_polysilicon-1##1 net@254#9pin@153_polysilicon-1##2 8.99
C753 net@254#9pin@153_polysilicon-1##2 0 0.19fF
R352 net@254#9pin@153_polysilicon-1##2 net@254#9pin@153_polysilicon-1##3 8.99
C754 net@254#9pin@153_polysilicon-1##3 0 0.19fF
R353 net@254#9pin@153_polysilicon-1##3 net@254#10pin@154_polysilicon-1 8.99
R354 net@254#10pin@154_polysilicon-1 net@254#10pin@154_polysilicon-1##0 6.2
C755 net@254#10pin@154_polysilicon-1##0 0 0.105fF
R355 net@254#10pin@154_polysilicon-1##0 net@254 6.2
R356 net@255#7pmos@15_poly-right net@255#7pmos@15_poly-right##0 6.975
C756 net@255#7pmos@15_poly-right##0 0 0.118fF
R357 net@255#7pmos@15_poly-right##0 net@255#9pin@155_polysilicon-1 6.975
R358 net@255#9pin@155_polysilicon-1 net@255#9pin@155_polysilicon-1##0 9.864
C757 net@255#9pin@155_polysilicon-1##0 0 0.229fF
R359 net@255#9pin@155_polysilicon-1##0 net@255#9pin@155_polysilicon-1##1 9.864
C758 net@255#9pin@155_polysilicon-1##1 0 0.229fF
R360 net@255#9pin@155_polysilicon-1##1 net@255#9pin@155_polysilicon-1##2 9.864
C759 net@255#9pin@155_polysilicon-1##2 0 0.229fF
R361 net@255#9pin@155_polysilicon-1##2 net@255#9pin@155_polysilicon-1##3 9.864
C760 net@255#9pin@155_polysilicon-1##3 0 0.229fF
R362 net@255#9pin@155_polysilicon-1##3 net@255#9pin@155_polysilicon-1##4 9.864
C761 net@255#9pin@155_polysilicon-1##4 0 0.229fF
R363 net@255#9pin@155_polysilicon-1##4 net@255#9pin@155_polysilicon-1##5 9.864
C762 net@255#9pin@155_polysilicon-1##5 0 0.229fF
R364 net@255#9pin@155_polysilicon-1##5 net@255#9pin@155_polysilicon-1##6 9.864
C763 net@255#9pin@155_polysilicon-1##6 0 0.229fF
R365 net@255#9pin@155_polysilicon-1##6 net@255#9pin@155_polysilicon-1##7 9.864
C764 net@255#9pin@155_polysilicon-1##7 0 0.229fF
R366 net@255#9pin@155_polysilicon-1##7 net@255#9pin@155_polysilicon-1##8 9.864
C765 net@255#9pin@155_polysilicon-1##8 0 0.229fF
R367 net@255#9pin@155_polysilicon-1##8 net@255#9pin@155_polysilicon-1##9 9.864
C766 net@255#9pin@155_polysilicon-1##9 0 0.229fF
R368 net@255#9pin@155_polysilicon-1##9 net@255#10pin@156_polysilicon-1 9.864
R369 net@255#10pin@156_polysilicon-1 net@255#1pin@128_polysilicon-1 9.3
R370 net@275#5contact@68_metal-1-polysilicon-1 net@275#5contact@68_metal-1-polysilicon-1##0 9.3
C767 net@275#5contact@68_metal-1-polysilicon-1##0 0 0.157fF
R371 net@275#5contact@68_metal-1-polysilicon-1##0 net@275#6pin@157_polysilicon-1 9.3
R372 net@275#4pmos@14_poly-right net@275#4pmos@14_poly-right##0 6.975
C768 net@275#4pmos@14_poly-right##0 0 0.118fF
R373 net@275#4pmos@14_poly-right##0 net@275#9pin@158_polysilicon-1 6.975
R374 net@275#9pin@158_polysilicon-1 net@275#9pin@158_polysilicon-1##0 9.688
C769 net@275#9pin@158_polysilicon-1##0 0 0.231fF
R375 net@275#9pin@158_polysilicon-1##0 net@275#9pin@158_polysilicon-1##1 9.688
C770 net@275#9pin@158_polysilicon-1##1 0 0.231fF
R376 net@275#9pin@158_polysilicon-1##1 net@275#9pin@158_polysilicon-1##2 9.688
C771 net@275#9pin@158_polysilicon-1##2 0 0.231fF
R377 net@275#9pin@158_polysilicon-1##2 net@275#9pin@158_polysilicon-1##3 9.688
C772 net@275#9pin@158_polysilicon-1##3 0 0.231fF
R378 net@275#9pin@158_polysilicon-1##3 net@275#9pin@158_polysilicon-1##4 9.688
C773 net@275#9pin@158_polysilicon-1##4 0 0.231fF
R379 net@275#9pin@158_polysilicon-1##4 net@275#9pin@158_polysilicon-1##5 9.688
C774 net@275#9pin@158_polysilicon-1##5 0 0.231fF
R380 net@275#9pin@158_polysilicon-1##5 net@275#9pin@158_polysilicon-1##6 9.688
C775 net@275#9pin@158_polysilicon-1##6 0 0.231fF
R381 net@275#9pin@158_polysilicon-1##6 net@275#9pin@158_polysilicon-1##7 9.688
C776 net@275#9pin@158_polysilicon-1##7 0 0.231fF
R382 net@275#9pin@158_polysilicon-1##7 net@275#9pin@158_polysilicon-1##8 9.688
C777 net@275#9pin@158_polysilicon-1##8 0 0.231fF
R383 net@275#9pin@158_polysilicon-1##8 net@275#9pin@158_polysilicon-1##9 9.688
C778 net@275#9pin@158_polysilicon-1##9 0 0.231fF
R384 net@275#9pin@158_polysilicon-1##9 net@275#9pin@158_polysilicon-1##10 9.688
C779 net@275#9pin@158_polysilicon-1##10 0 0.231fF
R385 net@275#9pin@158_polysilicon-1##10 net@275#9pin@158_polysilicon-1##11 9.688
C780 net@275#9pin@158_polysilicon-1##11 0 0.231fF
R386 net@275#9pin@158_polysilicon-1##11 net@275#9pin@158_polysilicon-1##12 9.688
C781 net@275#9pin@158_polysilicon-1##12 0 0.231fF
R387 net@275#9pin@158_polysilicon-1##12 net@275#9pin@158_polysilicon-1##13 9.688
C782 net@275#9pin@158_polysilicon-1##13 0 0.231fF
R388 net@275#9pin@158_polysilicon-1##13 net@275#9pin@158_polysilicon-1##14 9.688
C783 net@275#9pin@158_polysilicon-1##14 0 0.231fF
R389 net@275#9pin@158_polysilicon-1##14 net@275#10pin@159_polysilicon-1 9.688
R390 net@275#6pin@157_polysilicon-1 net@275#6pin@157_polysilicon-1##0 8.525
C784 net@275#6pin@157_polysilicon-1##0 0 0.144fF
R391 net@275#6pin@157_polysilicon-1##0 net@275#10pin@159_polysilicon-1 8.525
R392 X4#21contact@69_metal-1-polysilicon-1 X4#21contact@69_metal-1-polysilicon-1##0 9.3
C785 X4#21contact@69_metal-1-polysilicon-1##0 0 0.157fF
R393 X4#21contact@69_metal-1-polysilicon-1##0 X4#13pin@160_polysilicon-1 9.3
R394 net@321 net@321##0 8.525
C786 net@321##0 0 0.173fF
R395 net@321##0 net@321##1 8.525
C787 net@321##1 0 0.173fF
R396 net@321##1 net@321##2 8.525
C788 net@321##2 0 0.173fF
R397 net@321##2 net@321#1pin@169_polysilicon-1 8.525
R398 net@321#4pin@179_polysilicon-1 net@321#4pin@179_polysilicon-1##0 9.92
C789 net@321#4pin@179_polysilicon-1##0 0 0.236fF
R399 net@321#4pin@179_polysilicon-1##0 net@321#4pin@179_polysilicon-1##1 9.92
C790 net@321#4pin@179_polysilicon-1##1 0 0.236fF
R400 net@321#4pin@179_polysilicon-1##1 net@321#4pin@179_polysilicon-1##2 9.92
C791 net@321#4pin@179_polysilicon-1##2 0 0.236fF
R401 net@321#4pin@179_polysilicon-1##2 net@321#4pin@179_polysilicon-1##3 9.92
C792 net@321#4pin@179_polysilicon-1##3 0 0.236fF
R402 net@321#4pin@179_polysilicon-1##3 net@321#4pin@179_polysilicon-1##4 9.92
C793 net@321#4pin@179_polysilicon-1##4 0 0.236fF
R403 net@321#4pin@179_polysilicon-1##4 net@321#4pin@179_polysilicon-1##5 9.92
C794 net@321#4pin@179_polysilicon-1##5 0 0.236fF
R404 net@321#4pin@179_polysilicon-1##5 net@321#4pin@179_polysilicon-1##6 9.92
C795 net@321#4pin@179_polysilicon-1##6 0 0.236fF
R405 net@321#4pin@179_polysilicon-1##6 net@321#4pin@179_polysilicon-1##7 9.92
C796 net@321#4pin@179_polysilicon-1##7 0 0.236fF
R406 net@321#4pin@179_polysilicon-1##7 net@321#4pin@179_polysilicon-1##8 9.92
C797 net@321#4pin@179_polysilicon-1##8 0 0.236fF
R407 net@321#4pin@179_polysilicon-1##8 net@321#4pin@179_polysilicon-1##9 9.92
C798 net@321#4pin@179_polysilicon-1##9 0 0.236fF
R408 net@321#4pin@179_polysilicon-1##9 net@321#4pin@179_polysilicon-1##10 9.92
C799 net@321#4pin@179_polysilicon-1##10 0 0.236fF
R409 net@321#4pin@179_polysilicon-1##10 net@321#4pin@179_polysilicon-1##11 9.92
C800 net@321#4pin@179_polysilicon-1##11 0 0.236fF
R410 net@321#4pin@179_polysilicon-1##11 net@321#4pin@179_polysilicon-1##12 9.92
C801 net@321#4pin@179_polysilicon-1##12 0 0.236fF
R411 net@321#4pin@179_polysilicon-1##12 net@321#4pin@179_polysilicon-1##13 9.92
C802 net@321#4pin@179_polysilicon-1##13 0 0.236fF
R412 net@321#4pin@179_polysilicon-1##13 net@321#5pin@180_polysilicon-1 9.92
R413 net@325#12nmos@20_poly-left net@325#12nmos@20_poly-left##0 6.717
C803 net@325#12nmos@20_poly-left##0 0 0.128fF
R414 net@325#12nmos@20_poly-left##0 net@325#12nmos@20_poly-left##1 6.717
C804 net@325#12nmos@20_poly-left##1 0 0.128fF
R415 net@325#12nmos@20_poly-left##1 net@325#13pin@178_polysilicon-1 6.717
R416 net@325#13pin@178_polysilicon-1 net@325#13pin@178_polysilicon-1##0 8.525
C805 net@325#13pin@178_polysilicon-1##0 0 0.144fF
R417 net@325#13pin@178_polysilicon-1##0 net@325#6pmos@20_poly-right 8.525
R418 net@325 net@325#13pin@178_polysilicon-1 9.3
R419 net@352 net@352##0 7.75
C806 net@352##0 0 0.157fF
R420 net@352##0 net@352##1 7.75
C807 net@352##1 0 0.157fF
R421 net@352##1 net@352##2 7.75
C808 net@352##2 0 0.157fF
R422 net@352##2 net@352#1pin@167_polysilicon-1 7.75
R423 net@321#1pin@169_polysilicon-1 net@321#1pin@169_polysilicon-1##0 6.2
C809 net@321#1pin@169_polysilicon-1##0 0 0.105fF
R424 net@321#1pin@169_polysilicon-1##0 net@321#4pin@179_polysilicon-1 6.2
R425 net@352#2nmos@18_poly-right net@352#2nmos@18_poly-right##0 5.425
R426 net@352#2nmos@18_poly-right##0 net@352#3pin@183_polysilicon-1 5.425
R427 net@352#3pin@183_polysilicon-1 net@352#3pin@183_polysilicon-1##0 9.419
C810 net@352#3pin@183_polysilicon-1##0 0 0.221fF
R428 net@352#3pin@183_polysilicon-1##0 net@352#3pin@183_polysilicon-1##1 9.419
C811 net@352#3pin@183_polysilicon-1##1 0 0.221fF
R429 net@352#3pin@183_polysilicon-1##1 net@352#3pin@183_polysilicon-1##2 9.419
C812 net@352#3pin@183_polysilicon-1##2 0 0.221fF
R430 net@352#3pin@183_polysilicon-1##2 net@352#3pin@183_polysilicon-1##3 9.419
C813 net@352#3pin@183_polysilicon-1##3 0 0.221fF
R431 net@352#3pin@183_polysilicon-1##3 net@352#3pin@183_polysilicon-1##4 9.419
C814 net@352#3pin@183_polysilicon-1##4 0 0.221fF
R432 net@352#3pin@183_polysilicon-1##4 net@352#3pin@183_polysilicon-1##5 9.419
C815 net@352#3pin@183_polysilicon-1##5 0 0.221fF
R433 net@352#3pin@183_polysilicon-1##5 net@352#3pin@183_polysilicon-1##6 9.419
C816 net@352#3pin@183_polysilicon-1##6 0 0.221fF
R434 net@352#3pin@183_polysilicon-1##6 net@352#3pin@183_polysilicon-1##7 9.419
C817 net@352#3pin@183_polysilicon-1##7 0 0.221fF
R435 net@352#3pin@183_polysilicon-1##7 net@352#3pin@183_polysilicon-1##8 9.419
C818 net@352#3pin@183_polysilicon-1##8 0 0.221fF
R436 net@352#3pin@183_polysilicon-1##8 net@352#3pin@183_polysilicon-1##9 9.419
C819 net@352#3pin@183_polysilicon-1##9 0 0.221fF
R437 net@352#3pin@183_polysilicon-1##9 net@352#3pin@183_polysilicon-1##10 9.419
C820 net@352#3pin@183_polysilicon-1##10 0 0.221fF
R438 net@352#3pin@183_polysilicon-1##10 net@352#3pin@183_polysilicon-1##11 9.419
C821 net@352#3pin@183_polysilicon-1##11 0 0.221fF
R439 net@352#3pin@183_polysilicon-1##11 net@352#4pin@184_polysilicon-1 9.419
R440 net@352#1pin@167_polysilicon-1 net@352#1pin@167_polysilicon-1##0 8.525
C822 net@352#1pin@167_polysilicon-1##0 0 0.144fF
R441 net@352#1pin@167_polysilicon-1##0 net@352#5pin@168_polysilicon-1 8.525
R442 net@352#5pin@168_polysilicon-1 net@352#2nmos@18_poly-right 6.2
R443 X2#13nmos@22_poly-left X2#13nmos@22_poly-left##0 8.525
C823 X2#13nmos@22_poly-left##0 0 0.173fF
R444 X2#13nmos@22_poly-left##0 X2#13nmos@22_poly-left##1 8.525
C824 X2#13nmos@22_poly-left##1 0 0.173fF
R445 X2#13nmos@22_poly-left##1 X2#13nmos@22_poly-left##2 8.525
C825 X2#13nmos@22_poly-left##2 0 0.173fF
R446 X2#13nmos@22_poly-left##2 X2#14pin@188_polysilicon-1 8.525
R447 X2#17pin@198_polysilicon-1 X2#17pin@198_polysilicon-1##0 9.92
C826 X2#17pin@198_polysilicon-1##0 0 0.236fF
R448 X2#17pin@198_polysilicon-1##0 X2#17pin@198_polysilicon-1##1 9.92
C827 X2#17pin@198_polysilicon-1##1 0 0.236fF
R449 X2#17pin@198_polysilicon-1##1 X2#17pin@198_polysilicon-1##2 9.92
C828 X2#17pin@198_polysilicon-1##2 0 0.236fF
R450 X2#17pin@198_polysilicon-1##2 X2#17pin@198_polysilicon-1##3 9.92
C829 X2#17pin@198_polysilicon-1##3 0 0.236fF
R451 X2#17pin@198_polysilicon-1##3 X2#17pin@198_polysilicon-1##4 9.92
C830 X2#17pin@198_polysilicon-1##4 0 0.236fF
R452 X2#17pin@198_polysilicon-1##4 X2#17pin@198_polysilicon-1##5 9.92
C831 X2#17pin@198_polysilicon-1##5 0 0.236fF
R453 X2#17pin@198_polysilicon-1##5 X2#17pin@198_polysilicon-1##6 9.92
C832 X2#17pin@198_polysilicon-1##6 0 0.236fF
R454 X2#17pin@198_polysilicon-1##6 X2#17pin@198_polysilicon-1##7 9.92
C833 X2#17pin@198_polysilicon-1##7 0 0.236fF
R455 X2#17pin@198_polysilicon-1##7 X2#17pin@198_polysilicon-1##8 9.92
C834 X2#17pin@198_polysilicon-1##8 0 0.236fF
R456 X2#17pin@198_polysilicon-1##8 X2#17pin@198_polysilicon-1##9 9.92
C835 X2#17pin@198_polysilicon-1##9 0 0.236fF
R457 X2#17pin@198_polysilicon-1##9 X2#17pin@198_polysilicon-1##10 9.92
C836 X2#17pin@198_polysilicon-1##10 0 0.236fF
R458 X2#17pin@198_polysilicon-1##10 X2#17pin@198_polysilicon-1##11 9.92
C837 X2#17pin@198_polysilicon-1##11 0 0.236fF
R459 X2#17pin@198_polysilicon-1##11 X2#17pin@198_polysilicon-1##12 9.92
C838 X2#17pin@198_polysilicon-1##12 0 0.236fF
R460 X2#17pin@198_polysilicon-1##12 X2#17pin@198_polysilicon-1##13 9.92
C839 X2#17pin@198_polysilicon-1##13 0 0.236fF
R461 X2#17pin@198_polysilicon-1##13 X2#18pin@199_polysilicon-1 9.92
R462 net@367#12nmos@23_poly-left net@367#12nmos@23_poly-left##0 6.717
C840 net@367#12nmos@23_poly-left##0 0 0.128fF
R463 net@367#12nmos@23_poly-left##0 net@367#12nmos@23_poly-left##1 6.717
C841 net@367#12nmos@23_poly-left##1 0 0.128fF
R464 net@367#12nmos@23_poly-left##1 net@367#13pin@197_polysilicon-1 6.717
R465 net@367#13pin@197_polysilicon-1 net@367#13pin@197_polysilicon-1##0 8.525
C842 net@367#13pin@197_polysilicon-1##0 0 0.144fF
R466 net@367#13pin@197_polysilicon-1##0 net@367#6pmos@23_poly-right 8.525
R467 net@367 net@367#13pin@197_polysilicon-1 9.3
R468 X1#24pmos@21_poly-right X1#24pmos@21_poly-right##0 7.75
C843 X1#24pmos@21_poly-right##0 0 0.157fF
R469 X1#24pmos@21_poly-right##0 X1#24pmos@21_poly-right##1 7.75
C844 X1#24pmos@21_poly-right##1 0 0.157fF
R470 X1#24pmos@21_poly-right##1 X1#24pmos@21_poly-right##2 7.75
C845 X1#24pmos@21_poly-right##2 0 0.157fF
R471 X1#24pmos@21_poly-right##2 X1#25pin@186_polysilicon-1 7.75
R472 X2#14pin@188_polysilicon-1 X2#14pin@188_polysilicon-1##0 6.2
C846 X2#14pin@188_polysilicon-1##0 0 0.105fF
R473 X2#14pin@188_polysilicon-1##0 X2#17pin@198_polysilicon-1 6.2
R474 X1#26nmos@21_poly-right X1#26nmos@21_poly-right##0 5.425
R475 X1#26nmos@21_poly-right##0 X1#27pin@202_polysilicon-1 5.425
R476 X1#27pin@202_polysilicon-1 X1#27pin@202_polysilicon-1##0 9.419
C847 X1#27pin@202_polysilicon-1##0 0 0.221fF
R477 X1#27pin@202_polysilicon-1##0 X1#27pin@202_polysilicon-1##1 9.419
C848 X1#27pin@202_polysilicon-1##1 0 0.221fF
R478 X1#27pin@202_polysilicon-1##1 X1#27pin@202_polysilicon-1##2 9.419
C849 X1#27pin@202_polysilicon-1##2 0 0.221fF
R479 X1#27pin@202_polysilicon-1##2 X1#27pin@202_polysilicon-1##3 9.419
C850 X1#27pin@202_polysilicon-1##3 0 0.221fF
R480 X1#27pin@202_polysilicon-1##3 X1#27pin@202_polysilicon-1##4 9.419
C851 X1#27pin@202_polysilicon-1##4 0 0.221fF
R481 X1#27pin@202_polysilicon-1##4 X1#27pin@202_polysilicon-1##5 9.419
C852 X1#27pin@202_polysilicon-1##5 0 0.221fF
R482 X1#27pin@202_polysilicon-1##5 X1#27pin@202_polysilicon-1##6 9.419
C853 X1#27pin@202_polysilicon-1##6 0 0.221fF
R483 X1#27pin@202_polysilicon-1##6 X1#27pin@202_polysilicon-1##7 9.419
C854 X1#27pin@202_polysilicon-1##7 0 0.221fF
R484 X1#27pin@202_polysilicon-1##7 X1#27pin@202_polysilicon-1##8 9.419
C855 X1#27pin@202_polysilicon-1##8 0 0.221fF
R485 X1#27pin@202_polysilicon-1##8 X1#27pin@202_polysilicon-1##9 9.419
C856 X1#27pin@202_polysilicon-1##9 0 0.221fF
R486 X1#27pin@202_polysilicon-1##9 X1#27pin@202_polysilicon-1##10 9.419
C857 X1#27pin@202_polysilicon-1##10 0 0.221fF
R487 X1#27pin@202_polysilicon-1##10 X1#27pin@202_polysilicon-1##11 9.419
C858 X1#27pin@202_polysilicon-1##11 0 0.221fF
R488 X1#27pin@202_polysilicon-1##11 X1#28pin@203_polysilicon-1 9.419
R489 X1#25pin@186_polysilicon-1 X1#25pin@186_polysilicon-1##0 8.525
C859 X1#25pin@186_polysilicon-1##0 0 0.144fF
R490 X1#25pin@186_polysilicon-1##0 X1#29pin@187_polysilicon-1 8.525
R491 X1#29pin@187_polysilicon-1 X1#26nmos@21_poly-right 6.2
R492 X2#20pmos@24_poly-right X2#20pmos@24_poly-right##0 7.233
C860 X2#20pmos@24_poly-right##0 0 0.137fF
R493 X2#20pmos@24_poly-right##0 X2#20pmos@24_poly-right##1 7.233
C861 X2#20pmos@24_poly-right##1 0 0.137fF
R494 X2#20pmos@24_poly-right##1 X2#21pin@208_polysilicon-1 7.233
R495 X2#21pin@208_polysilicon-1 X2#21pin@208_polysilicon-1##0 7.75
C862 X2#21pin@208_polysilicon-1##0 0 0.147fF
R496 X2#21pin@208_polysilicon-1##0 X2#21pin@208_polysilicon-1##1 7.75
C863 X2#21pin@208_polysilicon-1##1 0 0.147fF
R497 X2#21pin@208_polysilicon-1##1 X2#22nmos@24_poly-left 7.75
R498 X2#23contact@91_metal-1-polysilicon-1 X2#21pin@208_polysilicon-1 8.68
R499 X1#31pmos@25_poly-right X1#31pmos@25_poly-right##0 7.233
C864 X1#31pmos@25_poly-right##0 0 0.137fF
R500 X1#31pmos@25_poly-right##0 X1#31pmos@25_poly-right##1 7.233
C865 X1#31pmos@25_poly-right##1 0 0.137fF
R501 X1#31pmos@25_poly-right##1 X1#32pin@213_polysilicon-1 7.233
R502 X1#32pin@213_polysilicon-1 X1#32pin@213_polysilicon-1##0 7.75
C866 X1#32pin@213_polysilicon-1##0 0 0.147fF
R503 X1#32pin@213_polysilicon-1##0 X1#32pin@213_polysilicon-1##1 7.75
C867 X1#32pin@213_polysilicon-1##1 0 0.147fF
R504 X1#32pin@213_polysilicon-1##1 X1#33nmos@25_poly-left 7.75
R505 X1#34contact@96_metal-1-polysilicon-1 X1#32pin@213_polysilicon-1 8.68
R506 net@321#7contact@92_metal-1-p-act net@321#7contact@92_metal-1-p-act##0 8.525
C868 net@321#7contact@92_metal-1-p-act##0 0 0.144fF
R507 net@321#7contact@92_metal-1-p-act##0 net@321#5pin@180_polysilicon-1 8.525
R508 net@352#4pin@184_polysilicon-1 net@352#4pin@184_polysilicon-1##0 9.3
C869 net@352#4pin@184_polysilicon-1##0 0 0.157fF
R509 net@352#4pin@184_polysilicon-1##0 net@352#7contact@97_metal-1-p-act 9.3
R510 X2#18pin@199_polysilicon-1 X2#18pin@199_polysilicon-1##0 8.525
C870 X2#18pin@199_polysilicon-1##0 0 0.144fF
R511 X2#18pin@199_polysilicon-1##0 X2#23contact@91_metal-1-polysilicon-1 8.525
R512 X1#34contact@96_metal-1-polysilicon-1 X1#34contact@96_metal-1-polysilicon-1##0 9.3
C871 X1#34contact@96_metal-1-polysilicon-1##0 0 0.157fF
R513 X1#34contact@96_metal-1-polysilicon-1##0 X1#28pin@203_polysilicon-1 9.3
R514 X4#21contact@69_metal-1-polysilicon-1 X4#25pin@233_metal-1 8.951
R515 X3#18pmos@26_poly-right X3#18pmos@26_poly-right##0 7.233
C872 X3#18pmos@26_poly-right##0 0 0.137fF
R516 X3#18pmos@26_poly-right##0 X3#18pmos@26_poly-right##1 7.233
C873 X3#18pmos@26_poly-right##1 0 0.137fF
R517 X3#18pmos@26_poly-right##1 X3#19pin@244_polysilicon-1 7.233
R518 X3#19pin@244_polysilicon-1 X3#19pin@244_polysilicon-1##0 7.75
C874 X3#19pin@244_polysilicon-1##0 0 0.147fF
R519 X3#19pin@244_polysilicon-1##0 X3#19pin@244_polysilicon-1##1 7.75
C875 X3#19pin@244_polysilicon-1##1 0 0.147fF
R520 X3#19pin@244_polysilicon-1##1 X3#20nmos@26_poly-left 7.75
R521 X3#21contact@108_metal-1-polysilicon-1 X3#19pin@244_polysilicon-1 8.68
R522 net@275#26nmos@28_poly-left net@275#26nmos@28_poly-left##0 9.3
C876 net@275#26nmos@28_poly-left##0 0 0.177fF
R523 net@275#26nmos@28_poly-left##0 net@275#26nmos@28_poly-left##1 9.3
C877 net@275#26nmos@28_poly-left##1 0 0.177fF
R524 net@275#26nmos@28_poly-left##1 net@275#27pin@256_polysilicon-1 9.3
R525 net@275#27pin@256_polysilicon-1 net@275#28pin@257_polysilicon-1 7.75
R526 net@275#22pin@251_polysilicon-1 net@275#22pin@251_polysilicon-1##0 7.233
C878 net@275#22pin@251_polysilicon-1##0 0 0.137fF
R527 net@275#22pin@251_polysilicon-1##0 net@275#22pin@251_polysilicon-1##1 7.233
C879 net@275#22pin@251_polysilicon-1##1 0 0.137fF
R528 net@275#22pin@251_polysilicon-1##1 net@275#28pin@257_polysilicon-1 7.233
R529 net@517 net@517##0 8.783
C880 net@517##0 0 0.167fF
R530 net@517##0 net@517##1 8.783
C881 net@517##1 0 0.167fF
R531 net@517##1 net@517#1pin@259_polysilicon-1 8.783
R532 net@517#1pin@259_polysilicon-1 net@517#2pin@260_polysilicon-1 6.2
R533 net@517#2pin@260_polysilicon-1 net@517#2pin@260_polysilicon-1##0 8.783
C882 net@517#2pin@260_polysilicon-1##0 0 0.167fF
R534 net@517#2pin@260_polysilicon-1##0 net@517#2pin@260_polysilicon-1##1 8.783
C883 net@517#2pin@260_polysilicon-1##1 0 0.167fF
R535 net@517#2pin@260_polysilicon-1##1 net@517#3pmos@29_poly-right 8.783
R536 X2#35nmos@30_poly-left X2#35nmos@30_poly-left##0 5.425
R537 X2#35nmos@30_poly-left##0 X2#36pin@261_polysilicon-1 5.425
R538 X2#36pin@261_polysilicon-1 X2#36pin@261_polysilicon-1##0 8.783
C884 X2#36pin@261_polysilicon-1##0 0 0.167fF
R539 X2#36pin@261_polysilicon-1##0 X2#36pin@261_polysilicon-1##1 8.783
C885 X2#36pin@261_polysilicon-1##1 0 0.167fF
R540 X2#36pin@261_polysilicon-1##1 X2#37pin@262_polysilicon-1 8.783
R541 X2#37pin@262_polysilicon-1 X2#37pin@262_polysilicon-1##0 9.688
C886 X2#37pin@262_polysilicon-1##0 0 0.196fF
R542 X2#37pin@262_polysilicon-1##0 X2#37pin@262_polysilicon-1##1 9.688
C887 X2#37pin@262_polysilicon-1##1 0 0.196fF
R543 X2#37pin@262_polysilicon-1##1 X2#37pin@262_polysilicon-1##2 9.688
C888 X2#37pin@262_polysilicon-1##2 0 0.196fF
R544 X2#37pin@262_polysilicon-1##2 X2#33pin@255_polysilicon-1 9.688
R545 net@352#21pmos@27_poly-right net@352#21pmos@27_poly-right##0 9.817
C889 net@352#21pmos@27_poly-right##0 0 0.186fF
R546 net@352#21pmos@27_poly-right##0 net@352#21pmos@27_poly-right##1 9.817
C890 net@352#21pmos@27_poly-right##1 0 0.186fF
R547 net@352#21pmos@27_poly-right##1 net@352#22pin@263_polysilicon-1 9.817
R548 net@352#23nmos@27_poly-right net@352#23nmos@27_poly-right##0 5.425
R549 net@352#23nmos@27_poly-right##0 net@352#24pin@269_polysilicon-1 5.425
R550 net@352#24pin@269_polysilicon-1 net@352#24pin@269_polysilicon-1##0 9.455
C891 net@352#24pin@269_polysilicon-1##0 0 0.218fF
R551 net@352#24pin@269_polysilicon-1##0 net@352#24pin@269_polysilicon-1##1 9.455
C892 net@352#24pin@269_polysilicon-1##1 0 0.218fF
R552 net@352#24pin@269_polysilicon-1##1 net@352#24pin@269_polysilicon-1##2 9.455
C893 net@352#24pin@269_polysilicon-1##2 0 0.218fF
R553 net@352#24pin@269_polysilicon-1##2 net@352#24pin@269_polysilicon-1##3 9.455
C894 net@352#24pin@269_polysilicon-1##3 0 0.218fF
R554 net@352#24pin@269_polysilicon-1##3 net@352#24pin@269_polysilicon-1##4 9.455
C895 net@352#24pin@269_polysilicon-1##4 0 0.218fF
R555 net@352#24pin@269_polysilicon-1##4 net@352#24pin@269_polysilicon-1##5 9.455
C896 net@352#24pin@269_polysilicon-1##5 0 0.218fF
R556 net@352#24pin@269_polysilicon-1##5 net@352#24pin@269_polysilicon-1##6 9.455
C897 net@352#24pin@269_polysilicon-1##6 0 0.218fF
R557 net@352#24pin@269_polysilicon-1##6 net@352#24pin@269_polysilicon-1##7 9.455
C898 net@352#24pin@269_polysilicon-1##7 0 0.218fF
R558 net@352#24pin@269_polysilicon-1##7 net@352#24pin@269_polysilicon-1##8 9.455
C899 net@352#24pin@269_polysilicon-1##8 0 0.218fF
R559 net@352#24pin@269_polysilicon-1##8 net@352#18contact@119_metal-1-polysilicon-1 9.455
R560 net@275#22pin@251_polysilicon-1 net@275#22pin@251_polysilicon-1##0 6.2
C900 net@275#22pin@251_polysilicon-1##0 0 0.105fF
R561 net@275#22pin@251_polysilicon-1##0 net@275#31pin@271_polysilicon-1 6.2
R562 net@275#31pin@271_polysilicon-1 net@275#31pin@271_polysilicon-1##0 9.881
C901 net@275#31pin@271_polysilicon-1##0 0 0.222fF
R563 net@275#31pin@271_polysilicon-1##0 net@275#31pin@271_polysilicon-1##1 9.881
C902 net@275#31pin@271_polysilicon-1##1 0 0.222fF
R564 net@275#31pin@271_polysilicon-1##1 net@275#31pin@271_polysilicon-1##2 9.881
C903 net@275#31pin@271_polysilicon-1##2 0 0.222fF
R565 net@275#31pin@271_polysilicon-1##2 net@275#31pin@271_polysilicon-1##3 9.881
C904 net@275#31pin@271_polysilicon-1##3 0 0.222fF
R566 net@275#31pin@271_polysilicon-1##3 net@275#31pin@271_polysilicon-1##4 9.881
C905 net@275#31pin@271_polysilicon-1##4 0 0.222fF
R567 net@275#31pin@271_polysilicon-1##4 net@275#31pin@271_polysilicon-1##5 9.881
C906 net@275#31pin@271_polysilicon-1##5 0 0.222fF
R568 net@275#31pin@271_polysilicon-1##5 net@275#31pin@271_polysilicon-1##6 9.881
C907 net@275#31pin@271_polysilicon-1##6 0 0.222fF
R569 net@275#31pin@271_polysilicon-1##6 net@275#32pin@272_polysilicon-1 9.881
R570 net@275#32pin@272_polysilicon-1 net@275#32pin@272_polysilicon-1##0 9.3
C908 net@275#32pin@272_polysilicon-1##0 0 0.157fF
R571 net@275#32pin@272_polysilicon-1##0 net@275#5contact@68_metal-1-polysilicon-1 9.3
R572 net@517#6pin@274_polysilicon-1 net@517#6pin@274_polysilicon-1##0 9.3
C909 net@517#6pin@274_polysilicon-1##0 0 0.157fF
R573 net@517#6pin@274_polysilicon-1##0 net@517#4contact@122_metal-1-polysilicon-1 9.3
R574 net@517#3pmos@29_poly-right net@517#3pmos@29_poly-right##0 6.2
C910 net@517#3pmos@29_poly-right##0 0 0.105fF
R575 net@517#3pmos@29_poly-right##0 net@517#8pin@275_polysilicon-1 6.2
R576 net@517#8pin@275_polysilicon-1 net@517#8pin@275_polysilicon-1##0 9.494
C911 net@517#8pin@275_polysilicon-1##0 0 0.214fF
R577 net@517#8pin@275_polysilicon-1##0 net@517#8pin@275_polysilicon-1##1 9.494
C912 net@517#8pin@275_polysilicon-1##1 0 0.214fF
R578 net@517#8pin@275_polysilicon-1##1 net@517#8pin@275_polysilicon-1##2 9.494
C913 net@517#8pin@275_polysilicon-1##2 0 0.214fF
R579 net@517#8pin@275_polysilicon-1##2 net@517#8pin@275_polysilicon-1##3 9.494
C914 net@517#8pin@275_polysilicon-1##3 0 0.214fF
R580 net@517#8pin@275_polysilicon-1##3 net@517#8pin@275_polysilicon-1##4 9.494
C915 net@517#8pin@275_polysilicon-1##4 0 0.214fF
R581 net@517#8pin@275_polysilicon-1##4 net@517#8pin@275_polysilicon-1##5 9.494
C916 net@517#8pin@275_polysilicon-1##5 0 0.214fF
R582 net@517#8pin@275_polysilicon-1##5 net@517#8pin@275_polysilicon-1##6 9.494
C917 net@517#8pin@275_polysilicon-1##6 0 0.214fF
R583 net@517#8pin@275_polysilicon-1##6 net@517#9pin@276_polysilicon-1 9.494
R584 net@517#9pin@276_polysilicon-1 net@517#9pin@276_polysilicon-1##0 5.425
R585 net@517#9pin@276_polysilicon-1##0 net@517#6pin@274_polysilicon-1 5.425
R586 X2#40pin@278_polysilicon-1 X2#40pin@278_polysilicon-1##0 9.3
C918 X2#40pin@278_polysilicon-1##0 0 0.157fF
R587 X2#40pin@278_polysilicon-1##0 X2#38contact@123_metal-1-polysilicon-1 9.3
R588 X2#35nmos@30_poly-left X2#35nmos@30_poly-left##0 5.425
R589 X2#35nmos@30_poly-left##0 X2#42pin@279_polysilicon-1 5.425
R590 X2#40pin@278_polysilicon-1 X2#40pin@278_polysilicon-1##0 9.688
C919 X2#40pin@278_polysilicon-1##0 0 0.196fF
R591 X2#40pin@278_polysilicon-1##0 X2#40pin@278_polysilicon-1##1 9.688
C920 X2#40pin@278_polysilicon-1##1 0 0.196fF
R592 X2#40pin@278_polysilicon-1##1 X2#40pin@278_polysilicon-1##2 9.688
C921 X2#40pin@278_polysilicon-1##2 0 0.196fF
R593 X2#40pin@278_polysilicon-1##2 X2#42pin@279_polysilicon-1 9.688
R594 net@352#22pin@263_polysilicon-1 net@352#22pin@263_polysilicon-1##0 6.2
C922 net@352#22pin@263_polysilicon-1##0 0 0.105fF
R595 net@352#22pin@263_polysilicon-1##0 net@352#26pin@281_polysilicon-1 6.2
R596 net@352#26pin@281_polysilicon-1 net@352#26pin@281_polysilicon-1##0 9.817
C923 net@352#26pin@281_polysilicon-1##0 0 0.186fF
R597 net@352#26pin@281_polysilicon-1##0 net@352#26pin@281_polysilicon-1##1 9.817
C924 net@352#26pin@281_polysilicon-1##1 0 0.186fF
R598 net@352#26pin@281_polysilicon-1##1 net@352#27pin@282_polysilicon-1 9.817
R599 net@352#27pin@282_polysilicon-1 net@352#27pin@282_polysilicon-1##0 5.425
R600 net@352#27pin@282_polysilicon-1##0 net@352#23nmos@27_poly-right 5.425
R601 net@275#5contact@68_metal-1-polysilicon-1 net@275#13pin@236_metal-1 8.687
R602 X4#27pmos@31_poly-right X4#27pmos@31_poly-right##0 7.233
C925 X4#27pmos@31_poly-right##0 0 0.137fF
R603 X4#27pmos@31_poly-right##0 X4#27pmos@31_poly-right##1 7.233
C926 X4#27pmos@31_poly-right##1 0 0.137fF
R604 X4#27pmos@31_poly-right##1 X4#28pin@289_polysilicon-1 7.233
R605 X4#28pin@289_polysilicon-1 X4#28pin@289_polysilicon-1##0 7.75
C927 X4#28pin@289_polysilicon-1##0 0 0.147fF
R606 X4#28pin@289_polysilicon-1##0 X4#28pin@289_polysilicon-1##1 7.75
C928 X4#28pin@289_polysilicon-1##1 0 0.147fF
R607 X4#28pin@289_polysilicon-1##1 X4#29nmos@31_poly-left 7.75
R608 X4#30contact@124_metal-1-polysilicon-1 X4#28pin@289_polysilicon-1 8.68
R609 X2#38contact@123_metal-1-polysilicon-1 X2#44pin@295_metal-1 8.834
R610 X4#30contact@124_metal-1-polysilicon-1 X4#32pin@300_metal-1 6.347
R611 net@597 net@597##0 9.3
C929 net@597##0 0 0.157fF
R612 net@597##0 net@597#1pin@338_polysilicon-1 9.3
R613 net@597#2pin@340_polysilicon-1 net@597#1pin@338_polysilicon-1 9.3
R614 net@597#4nmos@37_poly-left net@597#4nmos@37_poly-left##0 9.3
C930 net@597#4nmos@37_poly-left##0 0 0.212fF
R615 net@597#4nmos@37_poly-left##0 net@597#4nmos@37_poly-left##1 9.3
C931 net@597#4nmos@37_poly-left##1 0 0.212fF
R616 net@597#4nmos@37_poly-left##1 net@597#4nmos@37_poly-left##2 9.3
C932 net@597#4nmos@37_poly-left##2 0 0.212fF
R617 net@597#4nmos@37_poly-left##2 net@597#4nmos@37_poly-left##3 9.3
C933 net@597#4nmos@37_poly-left##3 0 0.212fF
R618 net@597#4nmos@37_poly-left##3 net@597#4nmos@37_poly-left##4 9.3
C934 net@597#4nmos@37_poly-left##4 0 0.212fF
R619 net@597#4nmos@37_poly-left##4 net@597#4nmos@37_poly-left##5 9.3
C935 net@597#4nmos@37_poly-left##5 0 0.212fF
R620 net@597#4nmos@37_poly-left##5 net@597#4nmos@37_poly-left##6 9.3
C936 net@597#4nmos@37_poly-left##6 0 0.212fF
R621 net@597#4nmos@37_poly-left##6 net@597#4nmos@37_poly-left##7 9.3
C937 net@597#4nmos@37_poly-left##7 0 0.212fF
R622 net@597#4nmos@37_poly-left##7 net@597#5pin@341_polysilicon-1 9.3
R623 net@597#5pin@341_polysilicon-1 net@597#6pin@330_polysilicon-1 7.75
R624 net@597#2pin@340_polysilicon-1 net@597#2pin@340_polysilicon-1##0 9.688
C938 net@597#2pin@340_polysilicon-1##0 0 0.196fF
R625 net@597#2pin@340_polysilicon-1##0 net@597#2pin@340_polysilicon-1##1 9.688
C939 net@597#2pin@340_polysilicon-1##1 0 0.196fF
R626 net@597#2pin@340_polysilicon-1##1 net@597#2pin@340_polysilicon-1##2 9.688
C940 net@597#2pin@340_polysilicon-1##2 0 0.196fF
R627 net@597#2pin@340_polysilicon-1##2 net@597#5pin@341_polysilicon-1 9.688
R628 net@603 net@603##0 7.75
C941 net@603##0 0 0.131fF
R629 net@603##0 net@603#1pin@342_polysilicon-1 7.75
R630 X4#35pin@325_polysilicon-1 X4#35pin@325_polysilicon-1##0 8.525
C942 X4#35pin@325_polysilicon-1##0 0 0.144fF
R631 X4#35pin@325_polysilicon-1##0 X4#36pin@327_polysilicon-1 8.525
R632 net@603#1pin@342_polysilicon-1 net@603#1pin@342_polysilicon-1##0 9.688
C943 net@603#1pin@342_polysilicon-1##0 0 0.226fF
R633 net@603#1pin@342_polysilicon-1##0 net@603#1pin@342_polysilicon-1##1 9.688
C944 net@603#1pin@342_polysilicon-1##1 0 0.226fF
R634 net@603#1pin@342_polysilicon-1##1 net@603#1pin@342_polysilicon-1##2 9.688
C945 net@603#1pin@342_polysilicon-1##2 0 0.226fF
R635 net@603#1pin@342_polysilicon-1##2 net@603#1pin@342_polysilicon-1##3 9.688
C946 net@603#1pin@342_polysilicon-1##3 0 0.226fF
R636 net@603#1pin@342_polysilicon-1##3 net@603#1pin@342_polysilicon-1##4 9.688
C947 net@603#1pin@342_polysilicon-1##4 0 0.226fF
R637 net@603#1pin@342_polysilicon-1##4 net@603#1pin@342_polysilicon-1##5 9.688
C948 net@603#1pin@342_polysilicon-1##5 0 0.226fF
R638 net@603#1pin@342_polysilicon-1##5 net@603#1pin@342_polysilicon-1##6 9.688
C949 net@603#1pin@342_polysilicon-1##6 0 0.226fF
R639 net@603#1pin@342_polysilicon-1##6 net@603#1pin@342_polysilicon-1##7 9.688
C950 net@603#1pin@342_polysilicon-1##7 0 0.226fF
R640 net@603#1pin@342_polysilicon-1##7 net@603#1pin@342_polysilicon-1##8 9.688
C951 net@603#1pin@342_polysilicon-1##8 0 0.226fF
R641 net@603#1pin@342_polysilicon-1##8 net@603#1pin@342_polysilicon-1##9 9.688
C952 net@603#1pin@342_polysilicon-1##9 0 0.226fF
R642 net@603#1pin@342_polysilicon-1##9 net@603#1pin@342_polysilicon-1##10 9.688
C953 net@603#1pin@342_polysilicon-1##10 0 0.226fF
R643 net@603#1pin@342_polysilicon-1##10 net@603#2pin@343_polysilicon-1 9.688
R644 net@603#2pin@343_polysilicon-1 net@603#2pin@343_polysilicon-1##0 6.975
C954 net@603#2pin@343_polysilicon-1##0 0 0.118fF
R645 net@603#2pin@343_polysilicon-1##0 net@603#3pin@321_polysilicon-1 6.975
R646 net@607 net@607##0 6.2
C955 net@607##0 0 0.105fF
R647 net@607##0 net@607#1pin@344_polysilicon-1 6.2
R648 net@607#1pin@344_polysilicon-1 net@607#1pin@344_polysilicon-1##0 9.494
C956 net@607#1pin@344_polysilicon-1##0 0 0.226fF
R649 net@607#1pin@344_polysilicon-1##0 net@607#1pin@344_polysilicon-1##1 9.494
C957 net@607#1pin@344_polysilicon-1##1 0 0.226fF
R650 net@607#1pin@344_polysilicon-1##1 net@607#1pin@344_polysilicon-1##2 9.494
C958 net@607#1pin@344_polysilicon-1##2 0 0.226fF
R651 net@607#1pin@344_polysilicon-1##2 net@607#1pin@344_polysilicon-1##3 9.494
C959 net@607#1pin@344_polysilicon-1##3 0 0.226fF
R652 net@607#1pin@344_polysilicon-1##3 net@607#1pin@344_polysilicon-1##4 9.494
C960 net@607#1pin@344_polysilicon-1##4 0 0.226fF
R653 net@607#1pin@344_polysilicon-1##4 net@607#1pin@344_polysilicon-1##5 9.494
C961 net@607#1pin@344_polysilicon-1##5 0 0.226fF
R654 net@607#1pin@344_polysilicon-1##5 net@607#1pin@344_polysilicon-1##6 9.494
C962 net@607#1pin@344_polysilicon-1##6 0 0.226fF
R655 net@607#1pin@344_polysilicon-1##6 net@607#1pin@344_polysilicon-1##7 9.494
C963 net@607#1pin@344_polysilicon-1##7 0 0.226fF
R656 net@607#1pin@344_polysilicon-1##7 net@607#1pin@344_polysilicon-1##8 9.494
C964 net@607#1pin@344_polysilicon-1##8 0 0.226fF
R657 net@607#1pin@344_polysilicon-1##8 net@607#1pin@344_polysilicon-1##9 9.494
C965 net@607#1pin@344_polysilicon-1##9 0 0.226fF
R658 net@607#1pin@344_polysilicon-1##9 net@607#1pin@344_polysilicon-1##10 9.494
C966 net@607#1pin@344_polysilicon-1##10 0 0.226fF
R659 net@607#1pin@344_polysilicon-1##10 net@607#1pin@344_polysilicon-1##11 9.494
C967 net@607#1pin@344_polysilicon-1##11 0 0.226fF
R660 net@607#1pin@344_polysilicon-1##11 net@607#1pin@344_polysilicon-1##12 9.494
C968 net@607#1pin@344_polysilicon-1##12 0 0.226fF
R661 net@607#1pin@344_polysilicon-1##12 net@607#1pin@344_polysilicon-1##13 9.494
C969 net@607#1pin@344_polysilicon-1##13 0 0.226fF
R662 net@607#1pin@344_polysilicon-1##13 net@607#1pin@344_polysilicon-1##14 9.494
C970 net@607#1pin@344_polysilicon-1##14 0 0.226fF
R663 net@607#1pin@344_polysilicon-1##14 net@607#2pin@345_polysilicon-1 9.494
R664 X4#37nmos@33_poly-right X4#37nmos@33_poly-right##0 5.425
R665 X4#37nmos@33_poly-right##0 X4#38pin@346_polysilicon-1 5.425
R666 X4#36pin@327_polysilicon-1 X4#36pin@327_polysilicon-1##0 9.574
C971 X4#36pin@327_polysilicon-1##0 0 0.229fF
R667 X4#36pin@327_polysilicon-1##0 X4#36pin@327_polysilicon-1##1 9.574
C972 X4#36pin@327_polysilicon-1##1 0 0.229fF
R668 X4#36pin@327_polysilicon-1##1 X4#36pin@327_polysilicon-1##2 9.574
C973 X4#36pin@327_polysilicon-1##2 0 0.229fF
R669 X4#36pin@327_polysilicon-1##2 X4#36pin@327_polysilicon-1##3 9.574
C974 X4#36pin@327_polysilicon-1##3 0 0.229fF
R670 X4#36pin@327_polysilicon-1##3 X4#36pin@327_polysilicon-1##4 9.574
C975 X4#36pin@327_polysilicon-1##4 0 0.229fF
R671 X4#36pin@327_polysilicon-1##4 X4#36pin@327_polysilicon-1##5 9.574
C976 X4#36pin@327_polysilicon-1##5 0 0.229fF
R672 X4#36pin@327_polysilicon-1##5 X4#36pin@327_polysilicon-1##6 9.574
C977 X4#36pin@327_polysilicon-1##6 0 0.229fF
R673 X4#36pin@327_polysilicon-1##6 X4#36pin@327_polysilicon-1##7 9.574
C978 X4#36pin@327_polysilicon-1##7 0 0.229fF
R674 X4#36pin@327_polysilicon-1##7 X4#36pin@327_polysilicon-1##8 9.574
C979 X4#36pin@327_polysilicon-1##8 0 0.229fF
R675 X4#36pin@327_polysilicon-1##8 X4#36pin@327_polysilicon-1##9 9.574
C980 X4#36pin@327_polysilicon-1##9 0 0.229fF
R676 X4#36pin@327_polysilicon-1##9 X4#36pin@327_polysilicon-1##10 9.574
C981 X4#36pin@327_polysilicon-1##10 0 0.229fF
R677 X4#36pin@327_polysilicon-1##10 X4#36pin@327_polysilicon-1##11 9.574
C982 X4#36pin@327_polysilicon-1##11 0 0.229fF
R678 X4#36pin@327_polysilicon-1##11 X4#36pin@327_polysilicon-1##12 9.574
C983 X4#36pin@327_polysilicon-1##12 0 0.229fF
R679 X4#36pin@327_polysilicon-1##12 X4#36pin@327_polysilicon-1##13 9.574
C984 X4#36pin@327_polysilicon-1##13 0 0.229fF
R680 X4#36pin@327_polysilicon-1##13 X4#36pin@327_polysilicon-1##14 9.574
C985 X4#36pin@327_polysilicon-1##14 0 0.229fF
R681 X4#36pin@327_polysilicon-1##14 X4#36pin@327_polysilicon-1##15 9.574
C986 X4#36pin@327_polysilicon-1##15 0 0.229fF
R682 X4#36pin@327_polysilicon-1##15 X4#38pin@346_polysilicon-1 9.574
R683 net@612 net@612##0 6.975
C987 net@612##0 0 0.118fF
R684 net@612##0 net@612#1pin@348_polysilicon-1 6.975
R685 net@612#1pin@348_polysilicon-1 net@612#1pin@348_polysilicon-1##0 9.411
C988 net@612#1pin@348_polysilicon-1##0 0 0.222fF
R686 net@612#1pin@348_polysilicon-1##0 net@612#1pin@348_polysilicon-1##1 9.411
C989 net@612#1pin@348_polysilicon-1##1 0 0.222fF
R687 net@612#1pin@348_polysilicon-1##1 net@612#1pin@348_polysilicon-1##2 9.411
C990 net@612#1pin@348_polysilicon-1##2 0 0.222fF
R688 net@612#1pin@348_polysilicon-1##2 net@612#1pin@348_polysilicon-1##3 9.411
C991 net@612#1pin@348_polysilicon-1##3 0 0.222fF
R689 net@612#1pin@348_polysilicon-1##3 net@612#1pin@348_polysilicon-1##4 9.411
C992 net@612#1pin@348_polysilicon-1##4 0 0.222fF
R690 net@612#1pin@348_polysilicon-1##4 net@612#1pin@348_polysilicon-1##5 9.411
C993 net@612#1pin@348_polysilicon-1##5 0 0.222fF
R691 net@612#1pin@348_polysilicon-1##5 net@612#1pin@348_polysilicon-1##6 9.411
C994 net@612#1pin@348_polysilicon-1##6 0 0.222fF
R692 net@612#1pin@348_polysilicon-1##6 net@612#1pin@348_polysilicon-1##7 9.411
C995 net@612#1pin@348_polysilicon-1##7 0 0.222fF
R693 net@612#1pin@348_polysilicon-1##7 net@612#1pin@348_polysilicon-1##8 9.411
C996 net@612#1pin@348_polysilicon-1##8 0 0.222fF
R694 net@612#1pin@348_polysilicon-1##8 net@612#1pin@348_polysilicon-1##9 9.411
C997 net@612#1pin@348_polysilicon-1##9 0 0.222fF
R695 net@612#1pin@348_polysilicon-1##9 net@612#1pin@348_polysilicon-1##10 9.411
C998 net@612#1pin@348_polysilicon-1##10 0 0.222fF
R696 net@612#1pin@348_polysilicon-1##10 net@612#1pin@348_polysilicon-1##11 9.411
C999 net@612#1pin@348_polysilicon-1##11 0 0.222fF
R697 net@612#1pin@348_polysilicon-1##11 net@612#1pin@348_polysilicon-1##12 9.411
C1000 net@612#1pin@348_polysilicon-1##12 0 0.222fF
R698 net@612#1pin@348_polysilicon-1##12 net@612#2pin@324_polysilicon-1 9.411
R699 net@607#2pin@345_polysilicon-1 net@607#2pin@345_polysilicon-1##0 7.75
C1001 net@607#2pin@345_polysilicon-1##0 0 0.157fF
R700 net@607#2pin@345_polysilicon-1##0 net@607#2pin@345_polysilicon-1##1 7.75
C1002 net@607#2pin@345_polysilicon-1##1 0 0.157fF
R701 net@607#2pin@345_polysilicon-1##1 net@607#2pin@345_polysilicon-1##2 7.75
C1003 net@607#2pin@345_polysilicon-1##2 0 0.157fF
R702 net@607#2pin@345_polysilicon-1##2 net@607#3pin@349_polysilicon-1 7.75
R703 net@612 net@612##0 9.817
C1004 net@612##0 0 0.224fF
R704 net@612##0 net@612##1 9.817
C1005 net@612##1 0 0.224fF
R705 net@612##1 net@612##2 9.817
C1006 net@612##2 0 0.224fF
R706 net@612##2 net@612##3 9.817
C1007 net@612##3 0 0.224fF
R707 net@612##3 net@612##4 9.817
C1008 net@612##4 0 0.224fF
R708 net@612##4 net@612##5 9.817
C1009 net@612##5 0 0.224fF
R709 net@612##5 net@612##6 9.817
C1010 net@612##6 0 0.224fF
R710 net@612##6 net@612##7 9.817
C1011 net@612##7 0 0.224fF
R711 net@612##7 net@612#4pin@304_polysilicon-1 9.817
R712 net@612#4pin@304_polysilicon-1 net@612#4pin@304_polysilicon-1##0 7.233
C1012 net@612#4pin@304_polysilicon-1##0 0 0.137fF
R713 net@612#4pin@304_polysilicon-1##0 net@612#4pin@304_polysilicon-1##1 7.233
C1013 net@612#4pin@304_polysilicon-1##1 0 0.137fF
R714 net@612#4pin@304_polysilicon-1##1 net@612#5pin@305_polysilicon-1 7.233
R715 net@603#4contact@140_metal-1-polysilicon-1 net@603#4contact@140_metal-1-polysilicon-1##0 9.3
C1014 net@603#4contact@140_metal-1-polysilicon-1##0 0 0.157fF
R716 net@603#4contact@140_metal-1-polysilicon-1##0 net@603#5pin@307_polysilicon-1 9.3
R717 net@603#3pin@321_polysilicon-1 net@603#5pin@307_polysilicon-1 9.3
R718 net@587#14pmos@35_poly-right net@587#14pmos@35_poly-right##0 8.913
C1015 net@587#14pmos@35_poly-right##0 0 0.201fF
R719 net@587#14pmos@35_poly-right##0 net@587#14pmos@35_poly-right##1 8.913
C1016 net@587#14pmos@35_poly-right##1 0 0.201fF
R720 net@587#14pmos@35_poly-right##1 net@587#14pmos@35_poly-right##2 8.913
C1017 net@587#14pmos@35_poly-right##2 0 0.201fF
R721 net@587#14pmos@35_poly-right##2 net@587#14pmos@35_poly-right##3 8.913
C1018 net@587#14pmos@35_poly-right##3 0 0.201fF
R722 net@587#14pmos@35_poly-right##3 net@587#14pmos@35_poly-right##4 8.913
C1019 net@587#14pmos@35_poly-right##4 0 0.201fF
R723 net@587#14pmos@35_poly-right##4 net@587#14pmos@35_poly-right##5 8.913
C1020 net@587#14pmos@35_poly-right##5 0 0.201fF
R724 net@587#14pmos@35_poly-right##5 net@587#14pmos@35_poly-right##6 8.913
C1021 net@587#14pmos@35_poly-right##6 0 0.201fF
R725 net@587#14pmos@35_poly-right##6 net@587#16pin@303_polysilicon-1 8.913
R726 net@587#18nmos@35_poly-left net@587#18nmos@35_poly-left##0 9.688
C1022 net@587#18nmos@35_poly-left##0 0 0.196fF
R727 net@587#18nmos@35_poly-left##0 net@587#18nmos@35_poly-left##1 9.688
C1023 net@587#18nmos@35_poly-left##1 0 0.196fF
R728 net@587#18nmos@35_poly-left##1 net@587#18nmos@35_poly-left##2 9.688
C1024 net@587#18nmos@35_poly-left##2 0 0.196fF
R729 net@587#18nmos@35_poly-left##2 net@587#16pin@303_polysilicon-1 9.688
R730 net@587 net@587#16pin@303_polysilicon-1 7.44
R731 net@612#7contact@143_metal-1-polysilicon-1 net@612#7contact@143_metal-1-polysilicon-1##0 9.3
C1025 net@612#7contact@143_metal-1-polysilicon-1##0 0 0.157fF
R732 net@612#7contact@143_metal-1-polysilicon-1##0 net@612#8pin@322_polysilicon-1 9.3
R733 X4#40pmos@33_poly-right X4#40pmos@33_poly-right##0 9.881
C1026 X4#40pmos@33_poly-right##0 0 0.222fF
R734 X4#40pmos@33_poly-right##0 X4#40pmos@33_poly-right##1 9.881
C1027 X4#40pmos@33_poly-right##1 0 0.222fF
R735 X4#40pmos@33_poly-right##1 X4#40pmos@33_poly-right##2 9.881
C1028 X4#40pmos@33_poly-right##2 0 0.222fF
R736 X4#40pmos@33_poly-right##2 X4#40pmos@33_poly-right##3 9.881
C1029 X4#40pmos@33_poly-right##3 0 0.222fF
R737 X4#40pmos@33_poly-right##3 X4#40pmos@33_poly-right##4 9.881
C1030 X4#40pmos@33_poly-right##4 0 0.222fF
R738 X4#40pmos@33_poly-right##4 X4#40pmos@33_poly-right##5 9.881
C1031 X4#40pmos@33_poly-right##5 0 0.222fF
R739 X4#40pmos@33_poly-right##5 X4#40pmos@33_poly-right##6 9.881
C1032 X4#40pmos@33_poly-right##6 0 0.222fF
R740 X4#40pmos@33_poly-right##6 X4#41pin@316_polysilicon-1 9.881
R741 net@607#6pin@317_polysilicon-1 net@607#6pin@317_polysilicon-1##0 7.75
C1033 net@607#6pin@317_polysilicon-1##0 0 0.157fF
R742 net@607#6pin@317_polysilicon-1##0 net@607#6pin@317_polysilicon-1##1 7.75
C1034 net@607#6pin@317_polysilicon-1##1 0 0.157fF
R743 net@607#6pin@317_polysilicon-1##1 net@607#6pin@317_polysilicon-1##2 7.75
C1035 net@607#6pin@317_polysilicon-1##2 0 0.157fF
R744 net@607#6pin@317_polysilicon-1##2 net@607#7pin@318_polysilicon-1 7.75
R745 net@607#7pin@318_polysilicon-1 net@607#7pin@318_polysilicon-1##0 8.636
C1036 net@607#7pin@318_polysilicon-1##0 0 0.191fF
R746 net@607#7pin@318_polysilicon-1##0 net@607#7pin@318_polysilicon-1##1 8.636
C1037 net@607#7pin@318_polysilicon-1##1 0 0.191fF
R747 net@607#7pin@318_polysilicon-1##1 net@607#7pin@318_polysilicon-1##2 8.636
C1038 net@607#7pin@318_polysilicon-1##2 0 0.191fF
R748 net@607#7pin@318_polysilicon-1##2 net@607#7pin@318_polysilicon-1##3 8.636
C1039 net@607#7pin@318_polysilicon-1##3 0 0.191fF
R749 net@607#7pin@318_polysilicon-1##3 net@607#7pin@318_polysilicon-1##4 8.636
C1040 net@607#7pin@318_polysilicon-1##4 0 0.191fF
R750 net@607#7pin@318_polysilicon-1##4 net@607#7pin@318_polysilicon-1##5 8.636
C1041 net@607#7pin@318_polysilicon-1##5 0 0.191fF
R751 net@607#7pin@318_polysilicon-1##5 net@607#8pmos@34_poly-right 8.636
R752 net@603#7nmos@36_poly-left net@603#7nmos@36_poly-left##0 9.521
C1042 net@603#7nmos@36_poly-left##0 0 0.211fF
R753 net@603#7nmos@36_poly-left##0 net@603#7nmos@36_poly-left##1 9.521
C1043 net@603#7nmos@36_poly-left##1 0 0.211fF
R754 net@603#7nmos@36_poly-left##1 net@603#7nmos@36_poly-left##2 9.521
C1044 net@603#7nmos@36_poly-left##2 0 0.211fF
R755 net@603#7nmos@36_poly-left##2 net@603#7nmos@36_poly-left##3 9.521
C1045 net@603#7nmos@36_poly-left##3 0 0.211fF
R756 net@603#7nmos@36_poly-left##3 net@603#7nmos@36_poly-left##4 9.521
C1046 net@603#7nmos@36_poly-left##4 0 0.211fF
R757 net@603#7nmos@36_poly-left##4 net@603#7nmos@36_poly-left##5 9.521
C1047 net@603#7nmos@36_poly-left##5 0 0.211fF
R758 net@603#7nmos@36_poly-left##5 net@603#8pin@319_polysilicon-1 9.521
R759 net@603#8pin@319_polysilicon-1 net@603#8pin@319_polysilicon-1##0 8.06
C1048 net@603#8pin@319_polysilicon-1##0 0 0.17fF
R760 net@603#8pin@319_polysilicon-1##0 net@603#8pin@319_polysilicon-1##1 8.06
C1049 net@603#8pin@319_polysilicon-1##1 0 0.17fF
R761 net@603#8pin@319_polysilicon-1##1 net@603#8pin@319_polysilicon-1##2 8.06
C1050 net@603#8pin@319_polysilicon-1##2 0 0.17fF
R762 net@603#8pin@319_polysilicon-1##2 net@603#8pin@319_polysilicon-1##3 8.06
C1051 net@603#8pin@319_polysilicon-1##3 0 0.17fF
R763 net@603#8pin@319_polysilicon-1##3 net@603#9pin@320_polysilicon-1 8.06
R764 net@603#9pin@320_polysilicon-1 net@603#9pin@320_polysilicon-1##0 8.68
C1052 net@603#9pin@320_polysilicon-1##0 0 0.183fF
R765 net@603#9pin@320_polysilicon-1##0 net@603#9pin@320_polysilicon-1##1 8.68
C1053 net@603#9pin@320_polysilicon-1##1 0 0.183fF
R766 net@603#9pin@320_polysilicon-1##1 net@603#9pin@320_polysilicon-1##2 8.68
C1054 net@603#9pin@320_polysilicon-1##2 0 0.183fF
R767 net@603#9pin@320_polysilicon-1##2 net@603#9pin@320_polysilicon-1##3 8.68
C1055 net@603#9pin@320_polysilicon-1##3 0 0.183fF
R768 net@603#9pin@320_polysilicon-1##3 net@603 8.68
R769 net@612#8pin@322_polysilicon-1 net@612#8pin@322_polysilicon-1##0 8.525
C1056 net@612#8pin@322_polysilicon-1##0 0 0.144fF
R770 net@612#8pin@322_polysilicon-1##0 net@612#2pin@324_polysilicon-1 8.525
R771 net@607#6pin@317_polysilicon-1 net@607#6pin@317_polysilicon-1##0 9.92
C1057 net@607#6pin@317_polysilicon-1##0 0 0.209fF
R772 net@607#6pin@317_polysilicon-1##0 net@607#6pin@317_polysilicon-1##1 9.92
C1058 net@607#6pin@317_polysilicon-1##1 0 0.209fF
R773 net@607#6pin@317_polysilicon-1##1 net@607#6pin@317_polysilicon-1##2 9.92
C1059 net@607#6pin@317_polysilicon-1##2 0 0.209fF
R774 net@607#6pin@317_polysilicon-1##2 net@607#6pin@317_polysilicon-1##3 9.92
C1060 net@607#6pin@317_polysilicon-1##3 0 0.209fF
R775 net@607#6pin@317_polysilicon-1##3 net@607 9.92
R776 X4#41pin@316_polysilicon-1 X4#41pin@316_polysilicon-1##0 6.2
C1061 X4#41pin@316_polysilicon-1##0 0 0.105fF
R777 X4#41pin@316_polysilicon-1##0 X4#42pin@329_polysilicon-1 6.2
R778 X4#33contact@144_metal-1-polysilicon-1 X4#33contact@144_metal-1-polysilicon-1##0 9.3
C1062 X4#33contact@144_metal-1-polysilicon-1##0 0 0.157fF
R779 X4#33contact@144_metal-1-polysilicon-1##0 X4#35pin@325_polysilicon-1 9.3
R780 X4#42pin@329_polysilicon-1 X4#42pin@329_polysilicon-1##0 7.75
C1063 X4#42pin@329_polysilicon-1##0 0 0.157fF
R781 X4#42pin@329_polysilicon-1##0 X4#42pin@329_polysilicon-1##1 7.75
C1064 X4#42pin@329_polysilicon-1##1 0 0.157fF
R782 X4#42pin@329_polysilicon-1##1 X4#42pin@329_polysilicon-1##2 7.75
C1065 X4#42pin@329_polysilicon-1##2 0 0.157fF
R783 X4#42pin@329_polysilicon-1##2 X4#37nmos@33_poly-right 7.75
R784 net@597#6pin@330_polysilicon-1 net@597#6pin@330_polysilicon-1##0 9.3
C1066 net@597#6pin@330_polysilicon-1##0 0 0.202fF
R785 net@597#6pin@330_polysilicon-1##0 net@597#6pin@330_polysilicon-1##1 9.3
C1067 net@597#6pin@330_polysilicon-1##1 0 0.202fF
R786 net@597#6pin@330_polysilicon-1##1 net@597#6pin@330_polysilicon-1##2 9.3
C1068 net@597#6pin@330_polysilicon-1##2 0 0.202fF
R787 net@597#6pin@330_polysilicon-1##2 net@597#6pin@330_polysilicon-1##3 9.3
C1069 net@597#6pin@330_polysilicon-1##3 0 0.202fF
R788 net@597#6pin@330_polysilicon-1##3 net@597#6pin@330_polysilicon-1##4 9.3
C1070 net@597#6pin@330_polysilicon-1##4 0 0.202fF
R789 net@597#6pin@330_polysilicon-1##4 net@597#7pin@331_polysilicon-1 9.3
R790 net@597#7pin@331_polysilicon-1 net@597#7pin@331_polysilicon-1##0 9.3
C1071 net@597#7pin@331_polysilicon-1##0 0 0.157fF
R791 net@597#7pin@331_polysilicon-1##0 net@597#8pin@332_polysilicon-1 9.3
R792 X3#25pin@352_polysilicon-1 X3#26nmos@38_poly-left 6.2
R793 net@679#7nmos@40_poly-left net@679#7nmos@40_poly-left##0 6.717
C1072 net@679#7nmos@40_poly-left##0 0 0.128fF
R794 net@679#7nmos@40_poly-left##0 net@679#7nmos@40_poly-left##1 6.717
C1073 net@679#7nmos@40_poly-left##1 0 0.128fF
R795 net@679#7nmos@40_poly-left##1 net@679#8pin@362_polysilicon-1 6.717
R796 net@679#8pin@362_polysilicon-1 net@679#8pin@362_polysilicon-1##0 8.525
C1074 net@679#8pin@362_polysilicon-1##0 0 0.144fF
R797 net@679#8pin@362_polysilicon-1##0 net@679#2pmos@40_poly-right 8.525
R798 net@679 net@679#8pin@362_polysilicon-1 9.3
R799 X3#27pmos@38_poly-right X3#27pmos@38_poly-right##0 8.525
C1075 X3#27pmos@38_poly-right##0 0 0.144fF
R800 X3#27pmos@38_poly-right##0 X3#29pin@368_polysilicon-1 8.525
R801 X1#44nmos@39_poly-left X1#44nmos@39_poly-left##0 8.525
C1076 X1#44nmos@39_poly-left##0 0 0.173fF
R802 X1#44nmos@39_poly-left##0 X1#44nmos@39_poly-left##1 8.525
C1077 X1#44nmos@39_poly-left##1 0 0.173fF
R803 X1#44nmos@39_poly-left##1 X1#44nmos@39_poly-left##2 8.525
C1078 X1#44nmos@39_poly-left##2 0 0.173fF
R804 X1#44nmos@39_poly-left##2 X1#45pin@353_polysilicon-1 8.525
R805 X3#29pin@368_polysilicon-1 X3#29pin@368_polysilicon-1##0 9.3
C1079 X3#29pin@368_polysilicon-1##0 0 0.177fF
R806 X3#29pin@368_polysilicon-1##0 X3#29pin@368_polysilicon-1##1 9.3
C1080 X3#29pin@368_polysilicon-1##1 0 0.177fF
R807 X3#29pin@368_polysilicon-1##1 X3#25pin@352_polysilicon-1 9.3
R808 net@705 net@705##0 6.2
C1081 net@705##0 0 0.105fF
R809 net@705##0 net@705#1pin@369_polysilicon-1 6.2
R810 net@705#1pin@369_polysilicon-1 net@705#1pin@369_polysilicon-1##0 9.817
C1082 net@705#1pin@369_polysilicon-1##0 0 0.186fF
R811 net@705#1pin@369_polysilicon-1##0 net@705#1pin@369_polysilicon-1##1 9.817
C1083 net@705#1pin@369_polysilicon-1##1 0 0.186fF
R812 net@705#1pin@369_polysilicon-1##1 net@705#2pin@370_polysilicon-1 9.817
R813 X1#45pin@353_polysilicon-1 X1#45pin@353_polysilicon-1##0 6.975
C1084 X1#45pin@353_polysilicon-1##0 0 0.118fF
R814 X1#45pin@353_polysilicon-1##0 X1#49pin@375_polysilicon-1 6.975
R815 X1#49pin@375_polysilicon-1 X1#49pin@375_polysilicon-1##0 9.896
C1085 X1#49pin@375_polysilicon-1##0 0 0.233fF
R816 X1#49pin@375_polysilicon-1##0 X1#49pin@375_polysilicon-1##1 9.896
C1086 X1#49pin@375_polysilicon-1##1 0 0.233fF
R817 X1#49pin@375_polysilicon-1##1 X1#49pin@375_polysilicon-1##2 9.896
C1087 X1#49pin@375_polysilicon-1##2 0 0.233fF
R818 X1#49pin@375_polysilicon-1##2 X1#49pin@375_polysilicon-1##3 9.896
C1088 X1#49pin@375_polysilicon-1##3 0 0.233fF
R819 X1#49pin@375_polysilicon-1##3 X1#49pin@375_polysilicon-1##4 9.896
C1089 X1#49pin@375_polysilicon-1##4 0 0.233fF
R820 X1#49pin@375_polysilicon-1##4 X1#49pin@375_polysilicon-1##5 9.896
C1090 X1#49pin@375_polysilicon-1##5 0 0.233fF
R821 X1#49pin@375_polysilicon-1##5 X1#49pin@375_polysilicon-1##6 9.896
C1091 X1#49pin@375_polysilicon-1##6 0 0.233fF
R822 X1#49pin@375_polysilicon-1##6 X1#49pin@375_polysilicon-1##7 9.896
C1092 X1#49pin@375_polysilicon-1##7 0 0.233fF
R823 X1#49pin@375_polysilicon-1##7 X1#49pin@375_polysilicon-1##8 9.896
C1093 X1#49pin@375_polysilicon-1##8 0 0.233fF
R824 X1#49pin@375_polysilicon-1##8 X1#49pin@375_polysilicon-1##9 9.896
C1094 X1#49pin@375_polysilicon-1##9 0 0.233fF
R825 X1#49pin@375_polysilicon-1##9 X1#49pin@375_polysilicon-1##10 9.896
C1095 X1#49pin@375_polysilicon-1##10 0 0.233fF
R826 X1#49pin@375_polysilicon-1##10 X1#49pin@375_polysilicon-1##11 9.896
C1096 X1#49pin@375_polysilicon-1##11 0 0.233fF
R827 X1#49pin@375_polysilicon-1##11 X1#50pin@376_polysilicon-1 9.896
R828 X1#50pin@376_polysilicon-1 X1#50pin@376_polysilicon-1##0 8.06
C1097 X1#50pin@376_polysilicon-1##0 0 0.17fF
R829 X1#50pin@376_polysilicon-1##0 X1#50pin@376_polysilicon-1##1 8.06
C1098 X1#50pin@376_polysilicon-1##1 0 0.17fF
R830 X1#50pin@376_polysilicon-1##1 X1#50pin@376_polysilicon-1##2 8.06
C1099 X1#50pin@376_polysilicon-1##2 0 0.17fF
R831 X1#50pin@376_polysilicon-1##2 X1#50pin@376_polysilicon-1##3 8.06
C1100 X1#50pin@376_polysilicon-1##3 0 0.17fF
R832 X1#50pin@376_polysilicon-1##3 X1#41contact@158_metal-1-polysilicon-1 8.06
R833 X3#26nmos@38_poly-left X3#26nmos@38_poly-left##0 6.2
C1101 X3#26nmos@38_poly-left##0 0 0.105fF
R834 X3#26nmos@38_poly-left##0 X3#31pin@377_polysilicon-1 6.2
R835 X3#31pin@377_polysilicon-1 X3#31pin@377_polysilicon-1##0 9.419
C1102 X3#31pin@377_polysilicon-1##0 0 0.221fF
R836 X3#31pin@377_polysilicon-1##0 X3#31pin@377_polysilicon-1##1 9.419
C1103 X3#31pin@377_polysilicon-1##1 0 0.221fF
R837 X3#31pin@377_polysilicon-1##1 X3#31pin@377_polysilicon-1##2 9.419
C1104 X3#31pin@377_polysilicon-1##2 0 0.221fF
R838 X3#31pin@377_polysilicon-1##2 X3#31pin@377_polysilicon-1##3 9.419
C1105 X3#31pin@377_polysilicon-1##3 0 0.221fF
R839 X3#31pin@377_polysilicon-1##3 X3#31pin@377_polysilicon-1##4 9.419
C1106 X3#31pin@377_polysilicon-1##4 0 0.221fF
R840 X3#31pin@377_polysilicon-1##4 X3#31pin@377_polysilicon-1##5 9.419
C1107 X3#31pin@377_polysilicon-1##5 0 0.221fF
R841 X3#31pin@377_polysilicon-1##5 X3#31pin@377_polysilicon-1##6 9.419
C1108 X3#31pin@377_polysilicon-1##6 0 0.221fF
R842 X3#31pin@377_polysilicon-1##6 X3#31pin@377_polysilicon-1##7 9.419
C1109 X3#31pin@377_polysilicon-1##7 0 0.221fF
R843 X3#31pin@377_polysilicon-1##7 X3#31pin@377_polysilicon-1##8 9.419
C1110 X3#31pin@377_polysilicon-1##8 0 0.221fF
R844 X3#31pin@377_polysilicon-1##8 X3#31pin@377_polysilicon-1##9 9.419
C1111 X3#31pin@377_polysilicon-1##9 0 0.221fF
R845 X3#31pin@377_polysilicon-1##9 X3#31pin@377_polysilicon-1##10 9.419
C1112 X3#31pin@377_polysilicon-1##10 0 0.221fF
R846 X3#31pin@377_polysilicon-1##10 X3#31pin@377_polysilicon-1##11 9.419
C1113 X3#31pin@377_polysilicon-1##11 0 0.221fF
R847 X3#31pin@377_polysilicon-1##11 X3#23contact@152_metal-1-polysilicon-1 9.419
R848 net@705#3pmos@41_poly-right net@705#4pin@379_polysilicon-1 6.2
R849 net@705#4pin@379_polysilicon-1 net@705#4pin@379_polysilicon-1##0 9.3
C1114 net@705#4pin@379_polysilicon-1##0 0 0.157fF
R850 net@705#4pin@379_polysilicon-1##0 net@705#2pin@370_polysilicon-1 9.3
R851 net@705#4pin@379_polysilicon-1 net@705#4pin@379_polysilicon-1##0 9.817
C1115 net@705#4pin@379_polysilicon-1##0 0 0.213fF
R852 net@705#4pin@379_polysilicon-1##0 net@705#4pin@379_polysilicon-1##1 9.817
C1116 net@705#4pin@379_polysilicon-1##1 0 0.213fF
R853 net@705#4pin@379_polysilicon-1##1 net@705#4pin@379_polysilicon-1##2 9.817
C1117 net@705#4pin@379_polysilicon-1##2 0 0.213fF
R854 net@705#4pin@379_polysilicon-1##2 net@705#4pin@379_polysilicon-1##3 9.817
C1118 net@705#4pin@379_polysilicon-1##3 0 0.213fF
R855 net@705#4pin@379_polysilicon-1##3 net@705#4pin@379_polysilicon-1##4 9.817
C1119 net@705#4pin@379_polysilicon-1##4 0 0.213fF
R856 net@705#4pin@379_polysilicon-1##4 net@705#5pin@380_polysilicon-1 9.817
R857 net@705#5pin@380_polysilicon-1 net@705#5pin@380_polysilicon-1##0 7.75
C1120 net@705#5pin@380_polysilicon-1##0 0 0.131fF
R858 net@705#5pin@380_polysilicon-1##0 net@705#6contact@160_metal-1-polysilicon-1 7.75
R859 net@738#5nmos@44_poly-left net@738#5nmos@44_poly-left##0 6.717
C1121 net@738#5nmos@44_poly-left##0 0 0.128fF
R860 net@738#5nmos@44_poly-left##0 net@738#5nmos@44_poly-left##1 6.717
C1122 net@738#5nmos@44_poly-left##1 0 0.128fF
R861 net@738#5nmos@44_poly-left##1 net@738#6pin@396_polysilicon-1 6.717
R862 net@738#6pin@396_polysilicon-1 net@738#6pin@396_polysilicon-1##0 8.525
C1123 net@738#6pin@396_polysilicon-1##0 0 0.144fF
R863 net@738#6pin@396_polysilicon-1##0 net@738#7pin@391_polysilicon-1 8.525
R864 net@738 net@738#6pin@396_polysilicon-1 9.3
R865 net@352#32pmos@43_poly-left net@352#32pmos@43_poly-left##0 6.2
C1124 net@352#32pmos@43_poly-left##0 0 0.105fF
R866 net@352#32pmos@43_poly-left##0 net@352#33pin@397_polysilicon-1 6.2
R867 net@352#33pin@397_polysilicon-1 net@352#33pin@397_polysilicon-1##0 9.92
C1125 net@352#33pin@397_polysilicon-1##0 0 0.236fF
R868 net@352#33pin@397_polysilicon-1##0 net@352#33pin@397_polysilicon-1##1 9.92
C1126 net@352#33pin@397_polysilicon-1##1 0 0.236fF
R869 net@352#33pin@397_polysilicon-1##1 net@352#33pin@397_polysilicon-1##2 9.92
C1127 net@352#33pin@397_polysilicon-1##2 0 0.236fF
R870 net@352#33pin@397_polysilicon-1##2 net@352#33pin@397_polysilicon-1##3 9.92
C1128 net@352#33pin@397_polysilicon-1##3 0 0.236fF
R871 net@352#33pin@397_polysilicon-1##3 net@352#33pin@397_polysilicon-1##4 9.92
C1129 net@352#33pin@397_polysilicon-1##4 0 0.236fF
R872 net@352#33pin@397_polysilicon-1##4 net@352#33pin@397_polysilicon-1##5 9.92
C1130 net@352#33pin@397_polysilicon-1##5 0 0.236fF
R873 net@352#33pin@397_polysilicon-1##5 net@352#33pin@397_polysilicon-1##6 9.92
C1131 net@352#33pin@397_polysilicon-1##6 0 0.236fF
R874 net@352#33pin@397_polysilicon-1##6 net@352#33pin@397_polysilicon-1##7 9.92
C1132 net@352#33pin@397_polysilicon-1##7 0 0.236fF
R875 net@352#33pin@397_polysilicon-1##7 net@352#33pin@397_polysilicon-1##8 9.92
C1133 net@352#33pin@397_polysilicon-1##8 0 0.236fF
R876 net@352#33pin@397_polysilicon-1##8 net@352#33pin@397_polysilicon-1##9 9.92
C1134 net@352#33pin@397_polysilicon-1##9 0 0.236fF
R877 net@352#33pin@397_polysilicon-1##9 net@352#33pin@397_polysilicon-1##10 9.92
C1135 net@352#33pin@397_polysilicon-1##10 0 0.236fF
R878 net@352#33pin@397_polysilicon-1##10 net@352#33pin@397_polysilicon-1##11 9.92
C1136 net@352#33pin@397_polysilicon-1##11 0 0.236fF
R879 net@352#33pin@397_polysilicon-1##11 net@352#33pin@397_polysilicon-1##12 9.92
C1137 net@352#33pin@397_polysilicon-1##12 0 0.236fF
R880 net@352#33pin@397_polysilicon-1##12 net@352#33pin@397_polysilicon-1##13 9.92
C1138 net@352#33pin@397_polysilicon-1##13 0 0.236fF
R881 net@352#33pin@397_polysilicon-1##13 net@352#7contact@97_metal-1-p-act 9.92
R882 net@759 net@759##0 7.75
C1139 net@759##0 0 0.157fF
R883 net@759##0 net@759##1 7.75
C1140 net@759##1 0 0.157fF
R884 net@759##1 net@759##2 7.75
C1141 net@759##2 0 0.157fF
R885 net@759##2 net@759#1pin@384_polysilicon-1 7.75
R886 net@759#2nmos@42_poly-right net@759#2nmos@42_poly-right##0 5.425
R887 net@759#2nmos@42_poly-right##0 net@759#3pin@403_polysilicon-1 5.425
R888 net@759#3pin@403_polysilicon-1 net@759#3pin@403_polysilicon-1##0 9.419
C1142 net@759#3pin@403_polysilicon-1##0 0 0.221fF
R889 net@759#3pin@403_polysilicon-1##0 net@759#3pin@403_polysilicon-1##1 9.419
C1143 net@759#3pin@403_polysilicon-1##1 0 0.221fF
R890 net@759#3pin@403_polysilicon-1##1 net@759#3pin@403_polysilicon-1##2 9.419
C1144 net@759#3pin@403_polysilicon-1##2 0 0.221fF
R891 net@759#3pin@403_polysilicon-1##2 net@759#3pin@403_polysilicon-1##3 9.419
C1145 net@759#3pin@403_polysilicon-1##3 0 0.221fF
R892 net@759#3pin@403_polysilicon-1##3 net@759#3pin@403_polysilicon-1##4 9.419
C1146 net@759#3pin@403_polysilicon-1##4 0 0.221fF
R893 net@759#3pin@403_polysilicon-1##4 net@759#3pin@403_polysilicon-1##5 9.419
C1147 net@759#3pin@403_polysilicon-1##5 0 0.221fF
R894 net@759#3pin@403_polysilicon-1##5 net@759#3pin@403_polysilicon-1##6 9.419
C1148 net@759#3pin@403_polysilicon-1##6 0 0.221fF
R895 net@759#3pin@403_polysilicon-1##6 net@759#3pin@403_polysilicon-1##7 9.419
C1149 net@759#3pin@403_polysilicon-1##7 0 0.221fF
R896 net@759#3pin@403_polysilicon-1##7 net@759#3pin@403_polysilicon-1##8 9.419
C1150 net@759#3pin@403_polysilicon-1##8 0 0.221fF
R897 net@759#3pin@403_polysilicon-1##8 net@759#3pin@403_polysilicon-1##9 9.419
C1151 net@759#3pin@403_polysilicon-1##9 0 0.221fF
R898 net@759#3pin@403_polysilicon-1##9 net@759#3pin@403_polysilicon-1##10 9.419
C1152 net@759#3pin@403_polysilicon-1##10 0 0.221fF
R899 net@759#3pin@403_polysilicon-1##10 net@759#3pin@403_polysilicon-1##11 9.419
C1153 net@759#3pin@403_polysilicon-1##11 0 0.221fF
R900 net@759#3pin@403_polysilicon-1##11 net@759#4pin@404_polysilicon-1 9.419
R901 net@759#1pin@384_polysilicon-1 net@759#1pin@384_polysilicon-1##0 8.525
C1154 net@759#1pin@384_polysilicon-1##0 0 0.144fF
R902 net@759#1pin@384_polysilicon-1##0 net@759#6pin@385_polysilicon-1 8.525
R903 net@759#6pin@385_polysilicon-1 net@759#2nmos@42_poly-right 6.2
R904 net@352#38nmos@43_poly-left net@352#38nmos@43_poly-left##0 8.525
C1155 net@352#38nmos@43_poly-left##0 0 0.173fF
R905 net@352#38nmos@43_poly-left##0 net@352#38nmos@43_poly-left##1 8.525
C1156 net@352#38nmos@43_poly-left##1 0 0.173fF
R906 net@352#38nmos@43_poly-left##1 net@352#38nmos@43_poly-left##2 8.525
C1157 net@352#38nmos@43_poly-left##2 0 0.173fF
R907 net@352#38nmos@43_poly-left##2 net@352#32pmos@43_poly-left 8.525
R908 net@785#5nmos@47_poly-left net@785#5nmos@47_poly-left##0 6.717
C1158 net@785#5nmos@47_poly-left##0 0 0.128fF
R909 net@785#5nmos@47_poly-left##0 net@785#5nmos@47_poly-left##1 6.717
C1159 net@785#5nmos@47_poly-left##1 0 0.128fF
R910 net@785#5nmos@47_poly-left##1 net@785#6pin@418_polysilicon-1 6.717
R911 net@785#6pin@418_polysilicon-1 net@785#6pin@418_polysilicon-1##0 8.525
C1160 net@785#6pin@418_polysilicon-1##0 0 0.144fF
R912 net@785#6pin@418_polysilicon-1##0 net@785#7pin@413_polysilicon-1 8.525
R913 net@785 net@785#6pin@418_polysilicon-1 9.3
R914 X2#45pmos@46_poly-left X2#45pmos@46_poly-left##0 6.2
C1161 X2#45pmos@46_poly-left##0 0 0.105fF
R915 X2#45pmos@46_poly-left##0 X2#46pin@419_polysilicon-1 6.2
R916 X2#46pin@419_polysilicon-1 X2#46pin@419_polysilicon-1##0 9.92
C1162 X2#46pin@419_polysilicon-1##0 0 0.236fF
R917 X2#46pin@419_polysilicon-1##0 X2#46pin@419_polysilicon-1##1 9.92
C1163 X2#46pin@419_polysilicon-1##1 0 0.236fF
R918 X2#46pin@419_polysilicon-1##1 X2#46pin@419_polysilicon-1##2 9.92
C1164 X2#46pin@419_polysilicon-1##2 0 0.236fF
R919 X2#46pin@419_polysilicon-1##2 X2#46pin@419_polysilicon-1##3 9.92
C1165 X2#46pin@419_polysilicon-1##3 0 0.236fF
R920 X2#46pin@419_polysilicon-1##3 X2#46pin@419_polysilicon-1##4 9.92
C1166 X2#46pin@419_polysilicon-1##4 0 0.236fF
R921 X2#46pin@419_polysilicon-1##4 X2#46pin@419_polysilicon-1##5 9.92
C1167 X2#46pin@419_polysilicon-1##5 0 0.236fF
R922 X2#46pin@419_polysilicon-1##5 X2#46pin@419_polysilicon-1##6 9.92
C1168 X2#46pin@419_polysilicon-1##6 0 0.236fF
R923 X2#46pin@419_polysilicon-1##6 X2#46pin@419_polysilicon-1##7 9.92
C1169 X2#46pin@419_polysilicon-1##7 0 0.236fF
R924 X2#46pin@419_polysilicon-1##7 X2#46pin@419_polysilicon-1##8 9.92
C1170 X2#46pin@419_polysilicon-1##8 0 0.236fF
R925 X2#46pin@419_polysilicon-1##8 X2#46pin@419_polysilicon-1##9 9.92
C1171 X2#46pin@419_polysilicon-1##9 0 0.236fF
R926 X2#46pin@419_polysilicon-1##9 X2#46pin@419_polysilicon-1##10 9.92
C1172 X2#46pin@419_polysilicon-1##10 0 0.236fF
R927 X2#46pin@419_polysilicon-1##10 X2#46pin@419_polysilicon-1##11 9.92
C1173 X2#46pin@419_polysilicon-1##11 0 0.236fF
R928 X2#46pin@419_polysilicon-1##11 X2#46pin@419_polysilicon-1##12 9.92
C1174 X2#46pin@419_polysilicon-1##12 0 0.236fF
R929 X2#46pin@419_polysilicon-1##12 X2#46pin@419_polysilicon-1##13 9.92
C1175 X2#46pin@419_polysilicon-1##13 0 0.236fF
R930 X2#46pin@419_polysilicon-1##13 X2#47contact@184_metal-1-polysilicon-1 9.92
R931 net@806 net@806##0 7.75
C1176 net@806##0 0 0.157fF
R932 net@806##0 net@806##1 7.75
C1177 net@806##1 0 0.157fF
R933 net@806##1 net@806##2 7.75
C1178 net@806##2 0 0.157fF
R934 net@806##2 net@806#1pin@406_polysilicon-1 7.75
R935 net@806#2nmos@45_poly-right net@806#2nmos@45_poly-right##0 5.425
R936 net@806#2nmos@45_poly-right##0 net@806#3pin@425_polysilicon-1 5.425
R937 net@806#3pin@425_polysilicon-1 net@806#3pin@425_polysilicon-1##0 9.419
C1179 net@806#3pin@425_polysilicon-1##0 0 0.221fF
R938 net@806#3pin@425_polysilicon-1##0 net@806#3pin@425_polysilicon-1##1 9.419
C1180 net@806#3pin@425_polysilicon-1##1 0 0.221fF
R939 net@806#3pin@425_polysilicon-1##1 net@806#3pin@425_polysilicon-1##2 9.419
C1181 net@806#3pin@425_polysilicon-1##2 0 0.221fF
R940 net@806#3pin@425_polysilicon-1##2 net@806#3pin@425_polysilicon-1##3 9.419
C1182 net@806#3pin@425_polysilicon-1##3 0 0.221fF
R941 net@806#3pin@425_polysilicon-1##3 net@806#3pin@425_polysilicon-1##4 9.419
C1183 net@806#3pin@425_polysilicon-1##4 0 0.221fF
R942 net@806#3pin@425_polysilicon-1##4 net@806#3pin@425_polysilicon-1##5 9.419
C1184 net@806#3pin@425_polysilicon-1##5 0 0.221fF
R943 net@806#3pin@425_polysilicon-1##5 net@806#3pin@425_polysilicon-1##6 9.419
C1185 net@806#3pin@425_polysilicon-1##6 0 0.221fF
R944 net@806#3pin@425_polysilicon-1##6 net@806#3pin@425_polysilicon-1##7 9.419
C1186 net@806#3pin@425_polysilicon-1##7 0 0.221fF
R945 net@806#3pin@425_polysilicon-1##7 net@806#3pin@425_polysilicon-1##8 9.419
C1187 net@806#3pin@425_polysilicon-1##8 0 0.221fF
R946 net@806#3pin@425_polysilicon-1##8 net@806#3pin@425_polysilicon-1##9 9.419
C1188 net@806#3pin@425_polysilicon-1##9 0 0.221fF
R947 net@806#3pin@425_polysilicon-1##9 net@806#3pin@425_polysilicon-1##10 9.419
C1189 net@806#3pin@425_polysilicon-1##10 0 0.221fF
R948 net@806#3pin@425_polysilicon-1##10 net@806#3pin@425_polysilicon-1##11 9.419
C1190 net@806#3pin@425_polysilicon-1##11 0 0.221fF
R949 net@806#3pin@425_polysilicon-1##11 net@806#4pin@426_polysilicon-1 9.419
R950 net@806#1pin@406_polysilicon-1 net@806#1pin@406_polysilicon-1##0 8.525
C1191 net@806#1pin@406_polysilicon-1##0 0 0.144fF
R951 net@806#1pin@406_polysilicon-1##0 net@806#6pin@407_polysilicon-1 8.525
R952 net@806#6pin@407_polysilicon-1 net@806#2nmos@45_poly-right 6.2
R953 X2#51nmos@46_poly-left X2#51nmos@46_poly-left##0 8.525
C1192 X2#51nmos@46_poly-left##0 0 0.173fF
R954 X2#51nmos@46_poly-left##0 X2#51nmos@46_poly-left##1 8.525
C1193 X2#51nmos@46_poly-left##1 0 0.173fF
R955 X2#51nmos@46_poly-left##1 X2#51nmos@46_poly-left##2 8.525
C1194 X2#51nmos@46_poly-left##2 0 0.173fF
R956 X2#51nmos@46_poly-left##2 X2#45pmos@46_poly-left 8.525
R957 net@832#5nmos@50_poly-left net@832#5nmos@50_poly-left##0 6.717
C1195 net@832#5nmos@50_poly-left##0 0 0.128fF
R958 net@832#5nmos@50_poly-left##0 net@832#5nmos@50_poly-left##1 6.717
C1196 net@832#5nmos@50_poly-left##1 0 0.128fF
R959 net@832#5nmos@50_poly-left##1 net@832#6pin@440_polysilicon-1 6.717
R960 net@832#6pin@440_polysilicon-1 net@832#6pin@440_polysilicon-1##0 8.525
C1197 net@832#6pin@440_polysilicon-1##0 0 0.144fF
R961 net@832#6pin@440_polysilicon-1##0 net@832#7pin@435_polysilicon-1 8.525
R962 net@832 net@832#6pin@440_polysilicon-1 9.3
R963 net@352#42pmos@49_poly-left net@352#42pmos@49_poly-left##0 6.2
C1198 net@352#42pmos@49_poly-left##0 0 0.105fF
R964 net@352#42pmos@49_poly-left##0 net@352#43pin@441_polysilicon-1 6.2
R965 net@352#43pin@441_polysilicon-1 net@352#43pin@441_polysilicon-1##0 9.92
C1199 net@352#43pin@441_polysilicon-1##0 0 0.236fF
R966 net@352#43pin@441_polysilicon-1##0 net@352#43pin@441_polysilicon-1##1 9.92
C1200 net@352#43pin@441_polysilicon-1##1 0 0.236fF
R967 net@352#43pin@441_polysilicon-1##1 net@352#43pin@441_polysilicon-1##2 9.92
C1201 net@352#43pin@441_polysilicon-1##2 0 0.236fF
R968 net@352#43pin@441_polysilicon-1##2 net@352#43pin@441_polysilicon-1##3 9.92
C1202 net@352#43pin@441_polysilicon-1##3 0 0.236fF
R969 net@352#43pin@441_polysilicon-1##3 net@352#43pin@441_polysilicon-1##4 9.92
C1203 net@352#43pin@441_polysilicon-1##4 0 0.236fF
R970 net@352#43pin@441_polysilicon-1##4 net@352#43pin@441_polysilicon-1##5 9.92
C1204 net@352#43pin@441_polysilicon-1##5 0 0.236fF
R971 net@352#43pin@441_polysilicon-1##5 net@352#43pin@441_polysilicon-1##6 9.92
C1205 net@352#43pin@441_polysilicon-1##6 0 0.236fF
R972 net@352#43pin@441_polysilicon-1##6 net@352#43pin@441_polysilicon-1##7 9.92
C1206 net@352#43pin@441_polysilicon-1##7 0 0.236fF
R973 net@352#43pin@441_polysilicon-1##7 net@352#43pin@441_polysilicon-1##8 9.92
C1207 net@352#43pin@441_polysilicon-1##8 0 0.236fF
R974 net@352#43pin@441_polysilicon-1##8 net@352#43pin@441_polysilicon-1##9 9.92
C1208 net@352#43pin@441_polysilicon-1##9 0 0.236fF
R975 net@352#43pin@441_polysilicon-1##9 net@352#43pin@441_polysilicon-1##10 9.92
C1209 net@352#43pin@441_polysilicon-1##10 0 0.236fF
R976 net@352#43pin@441_polysilicon-1##10 net@352#43pin@441_polysilicon-1##11 9.92
C1210 net@352#43pin@441_polysilicon-1##11 0 0.236fF
R977 net@352#43pin@441_polysilicon-1##11 net@352#43pin@441_polysilicon-1##12 9.92
C1211 net@352#43pin@441_polysilicon-1##12 0 0.236fF
R978 net@352#43pin@441_polysilicon-1##12 net@352#43pin@441_polysilicon-1##13 9.92
C1212 net@352#43pin@441_polysilicon-1##13 0 0.236fF
R979 net@352#43pin@441_polysilicon-1##13 net@352#7contact@97_metal-1-p-act 9.92
R980 X2#55pmos@48_poly-right X2#55pmos@48_poly-right##0 7.75
C1213 X2#55pmos@48_poly-right##0 0 0.157fF
R981 X2#55pmos@48_poly-right##0 X2#55pmos@48_poly-right##1 7.75
C1214 X2#55pmos@48_poly-right##1 0 0.157fF
R982 X2#55pmos@48_poly-right##1 X2#55pmos@48_poly-right##2 7.75
C1215 X2#55pmos@48_poly-right##2 0 0.157fF
R983 X2#55pmos@48_poly-right##2 X2#56pin@428_polysilicon-1 7.75
R984 X2#57nmos@48_poly-right X2#57nmos@48_poly-right##0 5.425
R985 X2#57nmos@48_poly-right##0 X2#58pin@447_polysilicon-1 5.425
R986 X2#58pin@447_polysilicon-1 X2#58pin@447_polysilicon-1##0 9.419
C1216 X2#58pin@447_polysilicon-1##0 0 0.221fF
R987 X2#58pin@447_polysilicon-1##0 X2#58pin@447_polysilicon-1##1 9.419
C1217 X2#58pin@447_polysilicon-1##1 0 0.221fF
R988 X2#58pin@447_polysilicon-1##1 X2#58pin@447_polysilicon-1##2 9.419
C1218 X2#58pin@447_polysilicon-1##2 0 0.221fF
R989 X2#58pin@447_polysilicon-1##2 X2#58pin@447_polysilicon-1##3 9.419
C1219 X2#58pin@447_polysilicon-1##3 0 0.221fF
R990 X2#58pin@447_polysilicon-1##3 X2#58pin@447_polysilicon-1##4 9.419
C1220 X2#58pin@447_polysilicon-1##4 0 0.221fF
R991 X2#58pin@447_polysilicon-1##4 X2#58pin@447_polysilicon-1##5 9.419
C1221 X2#58pin@447_polysilicon-1##5 0 0.221fF
R992 X2#58pin@447_polysilicon-1##5 X2#58pin@447_polysilicon-1##6 9.419
C1222 X2#58pin@447_polysilicon-1##6 0 0.221fF
R993 X2#58pin@447_polysilicon-1##6 X2#58pin@447_polysilicon-1##7 9.419
C1223 X2#58pin@447_polysilicon-1##7 0 0.221fF
R994 X2#58pin@447_polysilicon-1##7 X2#58pin@447_polysilicon-1##8 9.419
C1224 X2#58pin@447_polysilicon-1##8 0 0.221fF
R995 X2#58pin@447_polysilicon-1##8 X2#58pin@447_polysilicon-1##9 9.419
C1225 X2#58pin@447_polysilicon-1##9 0 0.221fF
R996 X2#58pin@447_polysilicon-1##9 X2#58pin@447_polysilicon-1##10 9.419
C1226 X2#58pin@447_polysilicon-1##10 0 0.221fF
R997 X2#58pin@447_polysilicon-1##10 X2#58pin@447_polysilicon-1##11 9.419
C1227 X2#58pin@447_polysilicon-1##11 0 0.221fF
R998 X2#58pin@447_polysilicon-1##11 X2#59pin@448_polysilicon-1 9.419
R999 X2#56pin@428_polysilicon-1 X2#56pin@428_polysilicon-1##0 8.525
C1228 X2#56pin@428_polysilicon-1##0 0 0.144fF
R1000 X2#56pin@428_polysilicon-1##0 X2#61pin@429_polysilicon-1 8.525
R1001 X2#61pin@429_polysilicon-1 X2#57nmos@48_poly-right 6.2
R1002 net@352#48nmos@49_poly-left net@352#48nmos@49_poly-left##0 8.525
C1229 net@352#48nmos@49_poly-left##0 0 0.173fF
R1003 net@352#48nmos@49_poly-left##0 net@352#48nmos@49_poly-left##1 8.525
C1230 net@352#48nmos@49_poly-left##1 0 0.173fF
R1004 net@352#48nmos@49_poly-left##1 net@352#48nmos@49_poly-left##2 8.525
C1231 net@352#48nmos@49_poly-left##2 0 0.173fF
R1005 net@352#48nmos@49_poly-left##2 net@352#42pmos@49_poly-left 8.525
R1006 X3#34pmos@51_poly-right X3#34pmos@51_poly-right##0 7.233
C1232 X3#34pmos@51_poly-right##0 0 0.137fF
R1007 X3#34pmos@51_poly-right##0 X3#34pmos@51_poly-right##1 7.233
C1233 X3#34pmos@51_poly-right##1 0 0.137fF
R1008 X3#34pmos@51_poly-right##1 X3#35pin@451_polysilicon-1 7.233
R1009 X3#35pin@451_polysilicon-1 X3#35pin@451_polysilicon-1##0 7.75
C1234 X3#35pin@451_polysilicon-1##0 0 0.147fF
R1010 X3#35pin@451_polysilicon-1##0 X3#35pin@451_polysilicon-1##1 7.75
C1235 X3#35pin@451_polysilicon-1##1 0 0.147fF
R1011 X3#35pin@451_polysilicon-1##1 X3#36nmos@51_poly-left 7.75
R1012 X3#37contact@197_metal-1-polysilicon-1 X3#35pin@451_polysilicon-1 8.68
R1013 X3#39pmos@52_poly-right X3#39pmos@52_poly-right##0 7.233
C1236 X3#39pmos@52_poly-right##0 0 0.137fF
R1014 X3#39pmos@52_poly-right##0 X3#39pmos@52_poly-right##1 7.233
C1237 X3#39pmos@52_poly-right##1 0 0.137fF
R1015 X3#39pmos@52_poly-right##1 X3#40pin@458_polysilicon-1 7.233
R1016 X3#40pin@458_polysilicon-1 X3#40pin@458_polysilicon-1##0 7.75
C1238 X3#40pin@458_polysilicon-1##0 0 0.147fF
R1017 X3#40pin@458_polysilicon-1##0 X3#40pin@458_polysilicon-1##1 7.75
C1239 X3#40pin@458_polysilicon-1##1 0 0.147fF
R1018 X3#40pin@458_polysilicon-1##1 X3#41nmos@52_poly-left 7.75
R1019 X3#42contact@202_metal-1-polysilicon-1 X3#40pin@458_polysilicon-1 8.68
R1020 X2#64pmos@53_poly-right X2#64pmos@53_poly-right##0 7.233
C1240 X2#64pmos@53_poly-right##0 0 0.137fF
R1021 X2#64pmos@53_poly-right##0 X2#64pmos@53_poly-right##1 7.233
C1241 X2#64pmos@53_poly-right##1 0 0.137fF
R1022 X2#64pmos@53_poly-right##1 X2#65pin@465_polysilicon-1 7.233
R1023 X2#65pin@465_polysilicon-1 X2#65pin@465_polysilicon-1##0 7.75
C1242 X2#65pin@465_polysilicon-1##0 0 0.147fF
R1024 X2#65pin@465_polysilicon-1##0 X2#65pin@465_polysilicon-1##1 7.75
C1243 X2#65pin@465_polysilicon-1##1 0 0.147fF
R1025 X2#65pin@465_polysilicon-1##1 X2#66nmos@53_poly-left 7.75
R1026 X2#67contact@207_metal-1-polysilicon-1 X2#65pin@465_polysilicon-1 8.68
R1027 net@612#7contact@143_metal-1-polysilicon-1 net@612#10contact@192_metal-1-p-act 4.105
R1028 X4#33contact@144_metal-1-polysilicon-1 X4#33contact@144_metal-1-polysilicon-1##0 5.762
C1244 X4#33contact@144_metal-1-polysilicon-1##0 0 26.895fF
R1029 X4#33contact@144_metal-1-polysilicon-1##0 X4#45pin@479_metal-1 5.762
R1030 X2#47contact@184_metal-1-polysilicon-1 X2#72pin@494_metal-1 4.485
R1031 X2#59pin@448_polysilicon-1 X2#73pin@496_metal-1 5.46
R1032 X1#55pmos@54_poly-right X1#55pmos@54_poly-right##0 7.233
C1245 X1#55pmos@54_poly-right##0 0 0.137fF
R1033 X1#55pmos@54_poly-right##0 X1#55pmos@54_poly-right##1 7.233
C1246 X1#55pmos@54_poly-right##1 0 0.137fF
R1034 X1#55pmos@54_poly-right##1 X1#56pin@499_polysilicon-1 7.233
R1035 X1#56pin@499_polysilicon-1 X1#56pin@499_polysilicon-1##0 7.75
C1247 X1#56pin@499_polysilicon-1##0 0 0.147fF
R1036 X1#56pin@499_polysilicon-1##0 X1#56pin@499_polysilicon-1##1 7.75
C1248 X1#56pin@499_polysilicon-1##1 0 0.147fF
R1037 X1#56pin@499_polysilicon-1##1 X1#57nmos@54_poly-left 7.75
R1038 X1#58contact@212_metal-1-polysilicon-1 X1#56pin@499_polysilicon-1 8.68
R1039 X1#58contact@212_metal-1-polysilicon-1 X1#60pin@505_metal-1 9.565
R1040 net@983 net@983#1pin@513_polysilicon-1 9.3
R1041 net@984 net@984##0 9.3
C1249 net@984##0 0 0.157fF
R1042 net@984##0 net@984#1pin@542_polysilicon-1 9.3
R1043 net@984#3pmos@56_poly-left net@984#3pmos@56_poly-left##0 6.975
C1250 net@984#3pmos@56_poly-left##0 0 0.118fF
R1044 net@984#3pmos@56_poly-left##0 net@984#4pin@544_polysilicon-1 6.975
R1045 net@984#4pin@544_polysilicon-1 net@984#4pin@544_polysilicon-1##0 9.688
C1251 net@984#4pin@544_polysilicon-1##0 0 0.231fF
R1046 net@984#4pin@544_polysilicon-1##0 net@984#4pin@544_polysilicon-1##1 9.688
C1252 net@984#4pin@544_polysilicon-1##1 0 0.231fF
R1047 net@984#4pin@544_polysilicon-1##1 net@984#4pin@544_polysilicon-1##2 9.688
C1253 net@984#4pin@544_polysilicon-1##2 0 0.231fF
R1048 net@984#4pin@544_polysilicon-1##2 net@984#4pin@544_polysilicon-1##3 9.688
C1254 net@984#4pin@544_polysilicon-1##3 0 0.231fF
R1049 net@984#4pin@544_polysilicon-1##3 net@984#4pin@544_polysilicon-1##4 9.688
C1255 net@984#4pin@544_polysilicon-1##4 0 0.231fF
R1050 net@984#4pin@544_polysilicon-1##4 net@984#4pin@544_polysilicon-1##5 9.688
C1256 net@984#4pin@544_polysilicon-1##5 0 0.231fF
R1051 net@984#4pin@544_polysilicon-1##5 net@984#4pin@544_polysilicon-1##6 9.688
C1257 net@984#4pin@544_polysilicon-1##6 0 0.231fF
R1052 net@984#4pin@544_polysilicon-1##6 net@984#4pin@544_polysilicon-1##7 9.688
C1258 net@984#4pin@544_polysilicon-1##7 0 0.231fF
R1053 net@984#4pin@544_polysilicon-1##7 net@984#4pin@544_polysilicon-1##8 9.688
C1259 net@984#4pin@544_polysilicon-1##8 0 0.231fF
R1054 net@984#4pin@544_polysilicon-1##8 net@984#4pin@544_polysilicon-1##9 9.688
C1260 net@984#4pin@544_polysilicon-1##9 0 0.231fF
R1055 net@984#4pin@544_polysilicon-1##9 net@984#4pin@544_polysilicon-1##10 9.688
C1261 net@984#4pin@544_polysilicon-1##10 0 0.231fF
R1056 net@984#4pin@544_polysilicon-1##10 net@984#4pin@544_polysilicon-1##11 9.688
C1262 net@984#4pin@544_polysilicon-1##11 0 0.231fF
R1057 net@984#4pin@544_polysilicon-1##11 net@984#4pin@544_polysilicon-1##12 9.688
C1263 net@984#4pin@544_polysilicon-1##12 0 0.231fF
R1058 net@984#4pin@544_polysilicon-1##12 net@984#4pin@544_polysilicon-1##13 9.688
C1264 net@984#4pin@544_polysilicon-1##13 0 0.231fF
R1059 net@984#4pin@544_polysilicon-1##13 net@984#4pin@544_polysilicon-1##14 9.688
C1265 net@984#4pin@544_polysilicon-1##14 0 0.231fF
R1060 net@984#4pin@544_polysilicon-1##14 net@984#5pin@545_polysilicon-1 9.688
R1061 net@984#1pin@542_polysilicon-1 net@984#1pin@542_polysilicon-1##0 8.525
C1266 net@984#1pin@542_polysilicon-1##0 0 0.144fF
R1062 net@984#1pin@542_polysilicon-1##0 net@984#5pin@545_polysilicon-1 8.525
R1063 X4#46contact@232_metal-1-polysilicon-1 X4#46contact@232_metal-1-polysilicon-1##0 9.3
C1267 X4#46contact@232_metal-1-polysilicon-1##0 0 0.157fF
R1064 X4#46contact@232_metal-1-polysilicon-1##0 X4#47pin@546_polysilicon-1 9.3
R1065 X4#47pin@546_polysilicon-1 X4#47pin@546_polysilicon-1##0 8.525
C1268 X4#47pin@546_polysilicon-1##0 0 0.144fF
R1066 X4#47pin@546_polysilicon-1##0 X4#49pin@548_polysilicon-1 8.525
R1067 X4#50nmos@55_poly-right X4#50nmos@55_poly-right##0 6.975
C1269 X4#50nmos@55_poly-right##0 0 0.118fF
R1068 X4#50nmos@55_poly-right##0 X4#51pin@549_polysilicon-1 6.975
R1069 X4#51pin@549_polysilicon-1 X4#51pin@549_polysilicon-1##0 9.777
C1270 X4#51pin@549_polysilicon-1##0 0 0.23fF
R1070 X4#51pin@549_polysilicon-1##0 X4#51pin@549_polysilicon-1##1 9.777
C1271 X4#51pin@549_polysilicon-1##1 0 0.23fF
R1071 X4#51pin@549_polysilicon-1##1 X4#51pin@549_polysilicon-1##2 9.777
C1272 X4#51pin@549_polysilicon-1##2 0 0.23fF
R1072 X4#51pin@549_polysilicon-1##2 X4#51pin@549_polysilicon-1##3 9.777
C1273 X4#51pin@549_polysilicon-1##3 0 0.23fF
R1073 X4#51pin@549_polysilicon-1##3 X4#51pin@549_polysilicon-1##4 9.777
C1274 X4#51pin@549_polysilicon-1##4 0 0.23fF
R1074 X4#51pin@549_polysilicon-1##4 X4#51pin@549_polysilicon-1##5 9.777
C1275 X4#51pin@549_polysilicon-1##5 0 0.23fF
R1075 X4#51pin@549_polysilicon-1##5 X4#51pin@549_polysilicon-1##6 9.777
C1276 X4#51pin@549_polysilicon-1##6 0 0.23fF
R1076 X4#51pin@549_polysilicon-1##6 X4#51pin@549_polysilicon-1##7 9.777
C1277 X4#51pin@549_polysilicon-1##7 0 0.23fF
R1077 X4#51pin@549_polysilicon-1##7 X4#51pin@549_polysilicon-1##8 9.777
C1278 X4#51pin@549_polysilicon-1##8 0 0.23fF
R1078 X4#51pin@549_polysilicon-1##8 X4#51pin@549_polysilicon-1##9 9.777
C1279 X4#51pin@549_polysilicon-1##9 0 0.23fF
R1079 X4#51pin@549_polysilicon-1##9 X4#51pin@549_polysilicon-1##10 9.777
C1280 X4#51pin@549_polysilicon-1##10 0 0.23fF
R1080 X4#51pin@549_polysilicon-1##10 X4#51pin@549_polysilicon-1##11 9.777
C1281 X4#51pin@549_polysilicon-1##11 0 0.23fF
R1081 X4#51pin@549_polysilicon-1##11 X4#49pin@548_polysilicon-1 9.777
R1082 X4#52pmos@55_poly-right X4#52pmos@55_poly-right##0 9.817
C1282 X4#52pmos@55_poly-right##0 0 0.224fF
R1083 X4#52pmos@55_poly-right##0 X4#52pmos@55_poly-right##1 9.817
C1283 X4#52pmos@55_poly-right##1 0 0.224fF
R1084 X4#52pmos@55_poly-right##1 X4#52pmos@55_poly-right##2 9.817
C1284 X4#52pmos@55_poly-right##2 0 0.224fF
R1085 X4#52pmos@55_poly-right##2 X4#52pmos@55_poly-right##3 9.817
C1285 X4#52pmos@55_poly-right##3 0 0.224fF
R1086 X4#52pmos@55_poly-right##3 X4#52pmos@55_poly-right##4 9.817
C1286 X4#52pmos@55_poly-right##4 0 0.224fF
R1087 X4#52pmos@55_poly-right##4 X4#52pmos@55_poly-right##5 9.817
C1287 X4#52pmos@55_poly-right##5 0 0.224fF
R1088 X4#52pmos@55_poly-right##5 X4#52pmos@55_poly-right##6 9.817
C1288 X4#52pmos@55_poly-right##6 0 0.224fF
R1089 X4#52pmos@55_poly-right##6 X4#52pmos@55_poly-right##7 9.817
C1289 X4#52pmos@55_poly-right##7 0 0.224fF
R1090 X4#52pmos@55_poly-right##7 X4#53pin@509_polysilicon-1 9.817
R1091 X4#53pin@509_polysilicon-1 X4#53pin@509_polysilicon-1##0 7.233
C1290 X4#53pin@509_polysilicon-1##0 0 0.137fF
R1092 X4#53pin@509_polysilicon-1##0 X4#53pin@509_polysilicon-1##1 7.233
C1291 X4#53pin@509_polysilicon-1##1 0 0.137fF
R1093 X4#53pin@509_polysilicon-1##1 X4#50nmos@55_poly-right 7.233
R1094 net@1008 net@1008##0 9.3
C1292 net@1008##0 0 0.157fF
R1095 net@1008##0 net@1008#1contact@229_metal-1-polysilicon-1 9.3
R1096 net@983#2contact@228_metal-1-polysilicon-1 net@983#2contact@228_metal-1-polysilicon-1##0 9.3
C1293 net@983#2contact@228_metal-1-polysilicon-1##0 0 0.157fF
R1097 net@983#2contact@228_metal-1-polysilicon-1##0 net@983#1pin@513_polysilicon-1 9.3
R1098 net@995#5pmos@58_poly-right net@995#5pmos@58_poly-right##0 8.913
C1294 net@995#5pmos@58_poly-right##0 0 0.201fF
R1099 net@995#5pmos@58_poly-right##0 net@995#5pmos@58_poly-right##1 8.913
C1295 net@995#5pmos@58_poly-right##1 0 0.201fF
R1100 net@995#5pmos@58_poly-right##1 net@995#5pmos@58_poly-right##2 8.913
C1296 net@995#5pmos@58_poly-right##2 0 0.201fF
R1101 net@995#5pmos@58_poly-right##2 net@995#5pmos@58_poly-right##3 8.913
C1297 net@995#5pmos@58_poly-right##3 0 0.201fF
R1102 net@995#5pmos@58_poly-right##3 net@995#5pmos@58_poly-right##4 8.913
C1298 net@995#5pmos@58_poly-right##4 0 0.201fF
R1103 net@995#5pmos@58_poly-right##4 net@995#5pmos@58_poly-right##5 8.913
C1299 net@995#5pmos@58_poly-right##5 0 0.201fF
R1104 net@995#5pmos@58_poly-right##5 net@995#5pmos@58_poly-right##6 8.913
C1300 net@995#5pmos@58_poly-right##6 0 0.201fF
R1105 net@995#5pmos@58_poly-right##6 net@995#9pin@508_polysilicon-1 8.913
R1106 net@995#11nmos@58_poly-left net@995#11nmos@58_poly-left##0 9.688
C1301 net@995#11nmos@58_poly-left##0 0 0.196fF
R1107 net@995#11nmos@58_poly-left##0 net@995#11nmos@58_poly-left##1 9.688
C1302 net@995#11nmos@58_poly-left##1 0 0.196fF
R1108 net@995#11nmos@58_poly-left##1 net@995#11nmos@58_poly-left##2 9.688
C1303 net@995#11nmos@58_poly-left##2 0 0.196fF
R1109 net@995#11nmos@58_poly-left##2 net@995#9pin@508_polysilicon-1 9.688
R1110 net@995 net@995#9pin@508_polysilicon-1 7.44
R1111 net@984#6nmos@56_poly-left net@984#6nmos@56_poly-left##0 9.3
C1304 net@984#6nmos@56_poly-left##0 0 0.202fF
R1112 net@984#6nmos@56_poly-left##0 net@984#6nmos@56_poly-left##1 9.3
C1305 net@984#6nmos@56_poly-left##1 0 0.202fF
R1113 net@984#6nmos@56_poly-left##1 net@984#6nmos@56_poly-left##2 9.3
C1306 net@984#6nmos@56_poly-left##2 0 0.202fF
R1114 net@984#6nmos@56_poly-left##2 net@984#6nmos@56_poly-left##3 9.3
C1307 net@984#6nmos@56_poly-left##3 0 0.202fF
R1115 net@984#6nmos@56_poly-left##3 net@984#6nmos@56_poly-left##4 9.3
C1308 net@984#6nmos@56_poly-left##4 0 0.202fF
R1116 net@984#6nmos@56_poly-left##4 net@984#7pin@524_polysilicon-1 9.3
R1117 net@984#7pin@524_polysilicon-1 net@984#7pin@524_polysilicon-1##0 6.975
C1309 net@984#7pin@524_polysilicon-1##0 0 0.118fF
R1118 net@984#7pin@524_polysilicon-1##0 net@984#8pin@525_polysilicon-1 6.975
R1119 net@984#3pmos@56_poly-left net@984#3pmos@56_poly-left##0 9.042
C1310 net@984#3pmos@56_poly-left##0 0 0.196fF
R1120 net@984#3pmos@56_poly-left##0 net@984#3pmos@56_poly-left##1 9.042
C1311 net@984#3pmos@56_poly-left##1 0 0.196fF
R1121 net@984#3pmos@56_poly-left##1 net@984#3pmos@56_poly-left##2 9.042
C1312 net@984#3pmos@56_poly-left##2 0 0.196fF
R1122 net@984#3pmos@56_poly-left##2 net@984#3pmos@56_poly-left##3 9.042
C1313 net@984#3pmos@56_poly-left##3 0 0.196fF
R1123 net@984#3pmos@56_poly-left##3 net@984#3pmos@56_poly-left##4 9.042
C1314 net@984#3pmos@56_poly-left##4 0 0.196fF
R1124 net@984#3pmos@56_poly-left##4 net@984#8pin@525_polysilicon-1 9.042
R1125 net@983#4nmos@57_poly-left net@983#4nmos@57_poly-left##0 9.817
C1315 net@983#4nmos@57_poly-left##0 0 0.213fF
R1126 net@983#4nmos@57_poly-left##0 net@983#4nmos@57_poly-left##1 9.817
C1316 net@983#4nmos@57_poly-left##1 0 0.213fF
R1127 net@983#4nmos@57_poly-left##1 net@983#4nmos@57_poly-left##2 9.817
C1317 net@983#4nmos@57_poly-left##2 0 0.213fF
R1128 net@983#4nmos@57_poly-left##2 net@983#4nmos@57_poly-left##3 9.817
C1318 net@983#4nmos@57_poly-left##3 0 0.213fF
R1129 net@983#4nmos@57_poly-left##3 net@983#4nmos@57_poly-left##4 9.817
C1319 net@983#4nmos@57_poly-left##4 0 0.213fF
R1130 net@983#4nmos@57_poly-left##4 net@983#5pin@527_polysilicon-1 9.817
R1131 net@983#5pin@527_polysilicon-1 net@983#5pin@527_polysilicon-1##0 6.975
C1320 net@983#5pin@527_polysilicon-1##0 0 0.118fF
R1132 net@983#5pin@527_polysilicon-1##0 net@983#6pin@528_polysilicon-1 6.975
R1133 net@983#6pin@528_polysilicon-1 net@983#6pin@528_polysilicon-1##0 7.75
C1321 net@983#6pin@528_polysilicon-1##0 0 0.157fF
R1134 net@983#6pin@528_polysilicon-1##0 net@983#6pin@528_polysilicon-1##1 7.75
C1322 net@983#6pin@528_polysilicon-1##1 0 0.157fF
R1135 net@983#6pin@528_polysilicon-1##1 net@983#6pin@528_polysilicon-1##2 7.75
C1323 net@983#6pin@528_polysilicon-1##2 0 0.157fF
R1136 net@983#6pin@528_polysilicon-1##2 net@983#7pin@529_polysilicon-1 7.75
R1137 net@983#7pin@529_polysilicon-1 net@983#7pin@529_polysilicon-1##0 9.3
C1324 net@983#7pin@529_polysilicon-1##0 0 0.188fF
R1138 net@983#7pin@529_polysilicon-1##0 net@983#7pin@529_polysilicon-1##1 9.3
C1325 net@983#7pin@529_polysilicon-1##1 0 0.188fF
R1139 net@983#7pin@529_polysilicon-1##1 net@983#7pin@529_polysilicon-1##2 9.3
C1326 net@983#7pin@529_polysilicon-1##2 0 0.188fF
R1140 net@983#7pin@529_polysilicon-1##2 net@983#8pmos@57_poly-right 9.3
R1141 net@1008#4nmos@59_poly-left net@1008#4nmos@59_poly-left##0 9.3
C1327 net@1008#4nmos@59_poly-left##0 0 0.214fF
R1142 net@1008#4nmos@59_poly-left##0 net@1008#4nmos@59_poly-left##1 9.3
C1328 net@1008#4nmos@59_poly-left##1 0 0.214fF
R1143 net@1008#4nmos@59_poly-left##1 net@1008#4nmos@59_poly-left##2 9.3
C1329 net@1008#4nmos@59_poly-left##2 0 0.214fF
R1144 net@1008#4nmos@59_poly-left##2 net@1008#4nmos@59_poly-left##3 9.3
C1330 net@1008#4nmos@59_poly-left##3 0 0.214fF
R1145 net@1008#4nmos@59_poly-left##3 net@1008#4nmos@59_poly-left##4 9.3
C1331 net@1008#4nmos@59_poly-left##4 0 0.214fF
R1146 net@1008#4nmos@59_poly-left##4 net@1008#4nmos@59_poly-left##5 9.3
C1332 net@1008#4nmos@59_poly-left##5 0 0.214fF
R1147 net@1008#4nmos@59_poly-left##5 net@1008#4nmos@59_poly-left##6 9.3
C1333 net@1008#4nmos@59_poly-left##6 0 0.214fF
R1148 net@1008#4nmos@59_poly-left##6 net@1008#4nmos@59_poly-left##7 9.3
C1334 net@1008#4nmos@59_poly-left##7 0 0.214fF
R1149 net@1008#4nmos@59_poly-left##7 net@1008#4nmos@59_poly-left##8 9.3
C1335 net@1008#4nmos@59_poly-left##8 0 0.214fF
R1150 net@1008#4nmos@59_poly-left##8 net@1008#5pin@530_polysilicon-1 9.3
R1151 net@1008#5pin@530_polysilicon-1 net@1008#5pin@530_polysilicon-1##0 8.99
C1336 net@1008#5pin@530_polysilicon-1##0 0 0.19fF
R1152 net@1008#5pin@530_polysilicon-1##0 net@1008#5pin@530_polysilicon-1##1 8.99
C1337 net@1008#5pin@530_polysilicon-1##1 0 0.19fF
R1153 net@1008#5pin@530_polysilicon-1##1 net@1008#5pin@530_polysilicon-1##2 8.99
C1338 net@1008#5pin@530_polysilicon-1##2 0 0.19fF
R1154 net@1008#5pin@530_polysilicon-1##2 net@1008#5pin@530_polysilicon-1##3 8.99
C1339 net@1008#5pin@530_polysilicon-1##3 0 0.19fF
R1155 net@1008#5pin@530_polysilicon-1##3 net@1008#6pin@531_polysilicon-1 8.99
R1156 net@1008#6pin@531_polysilicon-1 net@1008#6pin@531_polysilicon-1##0 8.525
C1340 net@1008#6pin@531_polysilicon-1##0 0 0.144fF
R1157 net@1008#6pin@531_polysilicon-1##0 net@1008#7pmos@59_poly-right 8.525
R1158 net@1008#4nmos@59_poly-left net@1008#4nmos@59_poly-left##0 5.425
R1159 net@1008#4nmos@59_poly-left##0 net@1008#9pin@538_polysilicon-1 5.425
R1160 net@1008#9pin@538_polysilicon-1 net@1008#9pin@538_polysilicon-1##0 8.99
C1341 net@1008#9pin@538_polysilicon-1##0 0 0.19fF
R1161 net@1008#9pin@538_polysilicon-1##0 net@1008#9pin@538_polysilicon-1##1 8.99
C1342 net@1008#9pin@538_polysilicon-1##1 0 0.19fF
R1162 net@1008#9pin@538_polysilicon-1##1 net@1008#9pin@538_polysilicon-1##2 8.99
C1343 net@1008#9pin@538_polysilicon-1##2 0 0.19fF
R1163 net@1008#9pin@538_polysilicon-1##2 net@1008#9pin@538_polysilicon-1##3 8.99
C1344 net@1008#9pin@538_polysilicon-1##3 0 0.19fF
R1164 net@1008#9pin@538_polysilicon-1##3 net@1008#10pin@539_polysilicon-1 8.99
R1165 net@1008#10pin@539_polysilicon-1 net@1008#10pin@539_polysilicon-1##0 6.2
C1345 net@1008#10pin@539_polysilicon-1##0 0 0.105fF
R1166 net@1008#10pin@539_polysilicon-1##0 net@1008 6.2
R1167 net@983#8pmos@57_poly-right net@983#8pmos@57_poly-right##0 6.975
C1346 net@983#8pmos@57_poly-right##0 0 0.118fF
R1168 net@983#8pmos@57_poly-right##0 net@983#10pin@540_polysilicon-1 6.975
R1169 net@983#10pin@540_polysilicon-1 net@983#10pin@540_polysilicon-1##0 9.864
C1347 net@983#10pin@540_polysilicon-1##0 0 0.229fF
R1170 net@983#10pin@540_polysilicon-1##0 net@983#10pin@540_polysilicon-1##1 9.864
C1348 net@983#10pin@540_polysilicon-1##1 0 0.229fF
R1171 net@983#10pin@540_polysilicon-1##1 net@983#10pin@540_polysilicon-1##2 9.864
C1349 net@983#10pin@540_polysilicon-1##2 0 0.229fF
R1172 net@983#10pin@540_polysilicon-1##2 net@983#10pin@540_polysilicon-1##3 9.864
C1350 net@983#10pin@540_polysilicon-1##3 0 0.229fF
R1173 net@983#10pin@540_polysilicon-1##3 net@983#10pin@540_polysilicon-1##4 9.864
C1351 net@983#10pin@540_polysilicon-1##4 0 0.229fF
R1174 net@983#10pin@540_polysilicon-1##4 net@983#10pin@540_polysilicon-1##5 9.864
C1352 net@983#10pin@540_polysilicon-1##5 0 0.229fF
R1175 net@983#10pin@540_polysilicon-1##5 net@983#10pin@540_polysilicon-1##6 9.864
C1353 net@983#10pin@540_polysilicon-1##6 0 0.229fF
R1176 net@983#10pin@540_polysilicon-1##6 net@983#10pin@540_polysilicon-1##7 9.864
C1354 net@983#10pin@540_polysilicon-1##7 0 0.229fF
R1177 net@983#10pin@540_polysilicon-1##7 net@983#10pin@540_polysilicon-1##8 9.864
C1355 net@983#10pin@540_polysilicon-1##8 0 0.229fF
R1178 net@983#10pin@540_polysilicon-1##8 net@983#10pin@540_polysilicon-1##9 9.864
C1356 net@983#10pin@540_polysilicon-1##9 0 0.229fF
R1179 net@983#10pin@540_polysilicon-1##9 net@983 9.864
R1180 net@352#54pin@564_polysilicon-1 net@352#54pin@564_polysilicon-1##0 9.92
C1357 net@352#54pin@564_polysilicon-1##0 0 0.236fF
R1181 net@352#54pin@564_polysilicon-1##0 net@352#54pin@564_polysilicon-1##1 9.92
C1358 net@352#54pin@564_polysilicon-1##1 0 0.236fF
R1182 net@352#54pin@564_polysilicon-1##1 net@352#54pin@564_polysilicon-1##2 9.92
C1359 net@352#54pin@564_polysilicon-1##2 0 0.236fF
R1183 net@352#54pin@564_polysilicon-1##2 net@352#54pin@564_polysilicon-1##3 9.92
C1360 net@352#54pin@564_polysilicon-1##3 0 0.236fF
R1184 net@352#54pin@564_polysilicon-1##3 net@352#54pin@564_polysilicon-1##4 9.92
C1361 net@352#54pin@564_polysilicon-1##4 0 0.236fF
R1185 net@352#54pin@564_polysilicon-1##4 net@352#54pin@564_polysilicon-1##5 9.92
C1362 net@352#54pin@564_polysilicon-1##5 0 0.236fF
R1186 net@352#54pin@564_polysilicon-1##5 net@352#54pin@564_polysilicon-1##6 9.92
C1363 net@352#54pin@564_polysilicon-1##6 0 0.236fF
R1187 net@352#54pin@564_polysilicon-1##6 net@352#54pin@564_polysilicon-1##7 9.92
C1364 net@352#54pin@564_polysilicon-1##7 0 0.236fF
R1188 net@352#54pin@564_polysilicon-1##7 net@352#54pin@564_polysilicon-1##8 9.92
C1365 net@352#54pin@564_polysilicon-1##8 0 0.236fF
R1189 net@352#54pin@564_polysilicon-1##8 net@352#54pin@564_polysilicon-1##9 9.92
C1366 net@352#54pin@564_polysilicon-1##9 0 0.236fF
R1190 net@352#54pin@564_polysilicon-1##9 net@352#54pin@564_polysilicon-1##10 9.92
C1367 net@352#54pin@564_polysilicon-1##10 0 0.236fF
R1191 net@352#54pin@564_polysilicon-1##10 net@352#54pin@564_polysilicon-1##11 9.92
C1368 net@352#54pin@564_polysilicon-1##11 0 0.236fF
R1192 net@352#54pin@564_polysilicon-1##11 net@352#54pin@564_polysilicon-1##12 9.92
C1369 net@352#54pin@564_polysilicon-1##12 0 0.236fF
R1193 net@352#54pin@564_polysilicon-1##12 net@352#54pin@564_polysilicon-1##13 9.92
C1370 net@352#54pin@564_polysilicon-1##13 0 0.236fF
R1194 net@352#54pin@564_polysilicon-1##13 net@352#7contact@97_metal-1-p-act 9.92
R1195 net@1072 net@1072##0 7.75
C1371 net@1072##0 0 0.157fF
R1196 net@1072##0 net@1072##1 7.75
C1372 net@1072##1 0 0.157fF
R1197 net@1072##1 net@1072##2 7.75
C1373 net@1072##2 0 0.157fF
R1198 net@1072##2 net@1072#1pin@551_polysilicon-1 7.75
R1199 net@1072#2nmos@60_poly-right net@1072#2nmos@60_poly-right##0 5.425
R1200 net@1072#2nmos@60_poly-right##0 net@1072#3pin@570_polysilicon-1 5.425
R1201 net@1072#3pin@570_polysilicon-1 net@1072#3pin@570_polysilicon-1##0 9.419
C1374 net@1072#3pin@570_polysilicon-1##0 0 0.221fF
R1202 net@1072#3pin@570_polysilicon-1##0 net@1072#3pin@570_polysilicon-1##1 9.419
C1375 net@1072#3pin@570_polysilicon-1##1 0 0.221fF
R1203 net@1072#3pin@570_polysilicon-1##1 net@1072#3pin@570_polysilicon-1##2 9.419
C1376 net@1072#3pin@570_polysilicon-1##2 0 0.221fF
R1204 net@1072#3pin@570_polysilicon-1##2 net@1072#3pin@570_polysilicon-1##3 9.419
C1377 net@1072#3pin@570_polysilicon-1##3 0 0.221fF
R1205 net@1072#3pin@570_polysilicon-1##3 net@1072#3pin@570_polysilicon-1##4 9.419
C1378 net@1072#3pin@570_polysilicon-1##4 0 0.221fF
R1206 net@1072#3pin@570_polysilicon-1##4 net@1072#3pin@570_polysilicon-1##5 9.419
C1379 net@1072#3pin@570_polysilicon-1##5 0 0.221fF
R1207 net@1072#3pin@570_polysilicon-1##5 net@1072#3pin@570_polysilicon-1##6 9.419
C1380 net@1072#3pin@570_polysilicon-1##6 0 0.221fF
R1208 net@1072#3pin@570_polysilicon-1##6 net@1072#3pin@570_polysilicon-1##7 9.419
C1381 net@1072#3pin@570_polysilicon-1##7 0 0.221fF
R1209 net@1072#3pin@570_polysilicon-1##7 net@1072#3pin@570_polysilicon-1##8 9.419
C1382 net@1072#3pin@570_polysilicon-1##8 0 0.221fF
R1210 net@1072#3pin@570_polysilicon-1##8 net@1072#3pin@570_polysilicon-1##9 9.419
C1383 net@1072#3pin@570_polysilicon-1##9 0 0.221fF
R1211 net@1072#3pin@570_polysilicon-1##9 net@1072#3pin@570_polysilicon-1##10 9.419
C1384 net@1072#3pin@570_polysilicon-1##10 0 0.221fF
R1212 net@1072#3pin@570_polysilicon-1##10 net@1072#3pin@570_polysilicon-1##11 9.419
C1385 net@1072#3pin@570_polysilicon-1##11 0 0.221fF
R1213 net@1072#3pin@570_polysilicon-1##11 net@1072#4pin@571_polysilicon-1 9.419
R1214 net@1072#1pin@551_polysilicon-1 net@1072#1pin@551_polysilicon-1##0 8.525
C1386 net@1072#1pin@551_polysilicon-1##0 0 0.144fF
R1215 net@1072#1pin@551_polysilicon-1##0 net@1072#6pin@552_polysilicon-1 8.525
R1216 net@1072#6pin@552_polysilicon-1 net@1072#2nmos@60_poly-right 6.2
R1217 net@352#56nmos@61_poly-left net@352#56nmos@61_poly-left##0 8.525
C1387 net@352#56nmos@61_poly-left##0 0 0.173fF
R1218 net@352#56nmos@61_poly-left##0 net@352#56nmos@61_poly-left##1 8.525
C1388 net@352#56nmos@61_poly-left##1 0 0.173fF
R1219 net@352#56nmos@61_poly-left##1 net@352#56nmos@61_poly-left##2 8.525
C1389 net@352#56nmos@61_poly-left##2 0 0.173fF
R1220 net@352#56nmos@61_poly-left##2 net@352#57pin@553_polysilicon-1 8.525
R1221 net@1068#13nmos@62_poly-left net@1068#13nmos@62_poly-left##0 6.717
C1390 net@1068#13nmos@62_poly-left##0 0 0.128fF
R1222 net@1068#13nmos@62_poly-left##0 net@1068#13nmos@62_poly-left##1 6.717
C1391 net@1068#13nmos@62_poly-left##1 0 0.128fF
R1223 net@1068#13nmos@62_poly-left##1 net@1068#14pin@563_polysilicon-1 6.717
R1224 net@1068#14pin@563_polysilicon-1 net@1068#14pin@563_polysilicon-1##0 8.525
C1392 net@1068#14pin@563_polysilicon-1##0 0 0.144fF
R1225 net@1068#14pin@563_polysilicon-1##0 net@1068#9pmos@62_poly-right 8.525
R1226 net@1068 net@1068#14pin@563_polysilicon-1 9.3
R1227 net@352#57pin@553_polysilicon-1 net@352#57pin@553_polysilicon-1##0 6.2
C1393 net@352#57pin@553_polysilicon-1##0 0 0.105fF
R1228 net@352#57pin@553_polysilicon-1##0 net@352#54pin@564_polysilicon-1 6.2
R1229 net@352#64pin@586_polysilicon-1 net@352#64pin@586_polysilicon-1##0 9.92
C1394 net@352#64pin@586_polysilicon-1##0 0 0.236fF
R1230 net@352#64pin@586_polysilicon-1##0 net@352#64pin@586_polysilicon-1##1 9.92
C1395 net@352#64pin@586_polysilicon-1##1 0 0.236fF
R1231 net@352#64pin@586_polysilicon-1##1 net@352#64pin@586_polysilicon-1##2 9.92
C1396 net@352#64pin@586_polysilicon-1##2 0 0.236fF
R1232 net@352#64pin@586_polysilicon-1##2 net@352#64pin@586_polysilicon-1##3 9.92
C1397 net@352#64pin@586_polysilicon-1##3 0 0.236fF
R1233 net@352#64pin@586_polysilicon-1##3 net@352#64pin@586_polysilicon-1##4 9.92
C1398 net@352#64pin@586_polysilicon-1##4 0 0.236fF
R1234 net@352#64pin@586_polysilicon-1##4 net@352#64pin@586_polysilicon-1##5 9.92
C1399 net@352#64pin@586_polysilicon-1##5 0 0.236fF
R1235 net@352#64pin@586_polysilicon-1##5 net@352#64pin@586_polysilicon-1##6 9.92
C1400 net@352#64pin@586_polysilicon-1##6 0 0.236fF
R1236 net@352#64pin@586_polysilicon-1##6 net@352#64pin@586_polysilicon-1##7 9.92
C1401 net@352#64pin@586_polysilicon-1##7 0 0.236fF
R1237 net@352#64pin@586_polysilicon-1##7 net@352#64pin@586_polysilicon-1##8 9.92
C1402 net@352#64pin@586_polysilicon-1##8 0 0.236fF
R1238 net@352#64pin@586_polysilicon-1##8 net@352#64pin@586_polysilicon-1##9 9.92
C1403 net@352#64pin@586_polysilicon-1##9 0 0.236fF
R1239 net@352#64pin@586_polysilicon-1##9 net@352#64pin@586_polysilicon-1##10 9.92
C1404 net@352#64pin@586_polysilicon-1##10 0 0.236fF
R1240 net@352#64pin@586_polysilicon-1##10 net@352#64pin@586_polysilicon-1##11 9.92
C1405 net@352#64pin@586_polysilicon-1##11 0 0.236fF
R1241 net@352#64pin@586_polysilicon-1##11 net@352#64pin@586_polysilicon-1##12 9.92
C1406 net@352#64pin@586_polysilicon-1##12 0 0.236fF
R1242 net@352#64pin@586_polysilicon-1##12 net@352#64pin@586_polysilicon-1##13 9.92
C1407 net@352#64pin@586_polysilicon-1##13 0 0.236fF
R1243 net@352#64pin@586_polysilicon-1##13 net@352#7contact@97_metal-1-p-act 9.92
R1244 X3#49pmos@63_poly-right X3#49pmos@63_poly-right##0 7.75
C1408 X3#49pmos@63_poly-right##0 0 0.157fF
R1245 X3#49pmos@63_poly-right##0 X3#49pmos@63_poly-right##1 7.75
C1409 X3#49pmos@63_poly-right##1 0 0.157fF
R1246 X3#49pmos@63_poly-right##1 X3#49pmos@63_poly-right##2 7.75
C1410 X3#49pmos@63_poly-right##2 0 0.157fF
R1247 X3#49pmos@63_poly-right##2 X3#50pin@573_polysilicon-1 7.75
R1248 X3#51nmos@63_poly-right X3#51nmos@63_poly-right##0 5.425
R1249 X3#51nmos@63_poly-right##0 X3#52pin@592_polysilicon-1 5.425
R1250 X3#52pin@592_polysilicon-1 X3#52pin@592_polysilicon-1##0 9.419
C1411 X3#52pin@592_polysilicon-1##0 0 0.221fF
R1251 X3#52pin@592_polysilicon-1##0 X3#52pin@592_polysilicon-1##1 9.419
C1412 X3#52pin@592_polysilicon-1##1 0 0.221fF
R1252 X3#52pin@592_polysilicon-1##1 X3#52pin@592_polysilicon-1##2 9.419
C1413 X3#52pin@592_polysilicon-1##2 0 0.221fF
R1253 X3#52pin@592_polysilicon-1##2 X3#52pin@592_polysilicon-1##3 9.419
C1414 X3#52pin@592_polysilicon-1##3 0 0.221fF
R1254 X3#52pin@592_polysilicon-1##3 X3#52pin@592_polysilicon-1##4 9.419
C1415 X3#52pin@592_polysilicon-1##4 0 0.221fF
R1255 X3#52pin@592_polysilicon-1##4 X3#52pin@592_polysilicon-1##5 9.419
C1416 X3#52pin@592_polysilicon-1##5 0 0.221fF
R1256 X3#52pin@592_polysilicon-1##5 X3#52pin@592_polysilicon-1##6 9.419
C1417 X3#52pin@592_polysilicon-1##6 0 0.221fF
R1257 X3#52pin@592_polysilicon-1##6 X3#52pin@592_polysilicon-1##7 9.419
C1418 X3#52pin@592_polysilicon-1##7 0 0.221fF
R1258 X3#52pin@592_polysilicon-1##7 X3#52pin@592_polysilicon-1##8 9.419
C1419 X3#52pin@592_polysilicon-1##8 0 0.221fF
R1259 X3#52pin@592_polysilicon-1##8 X3#52pin@592_polysilicon-1##9 9.419
C1420 X3#52pin@592_polysilicon-1##9 0 0.221fF
R1260 X3#52pin@592_polysilicon-1##9 X3#52pin@592_polysilicon-1##10 9.419
C1421 X3#52pin@592_polysilicon-1##10 0 0.221fF
R1261 X3#52pin@592_polysilicon-1##10 X3#52pin@592_polysilicon-1##11 9.419
C1422 X3#52pin@592_polysilicon-1##11 0 0.221fF
R1262 X3#52pin@592_polysilicon-1##11 X3#53pin@593_polysilicon-1 9.419
R1263 X3#50pin@573_polysilicon-1 X3#50pin@573_polysilicon-1##0 8.525
C1423 X3#50pin@573_polysilicon-1##0 0 0.144fF
R1264 X3#50pin@573_polysilicon-1##0 X3#55pin@574_polysilicon-1 8.525
R1265 X3#55pin@574_polysilicon-1 X3#51nmos@63_poly-right 6.2
R1266 net@352#66nmos@64_poly-left net@352#66nmos@64_poly-left##0 8.525
C1424 net@352#66nmos@64_poly-left##0 0 0.173fF
R1267 net@352#66nmos@64_poly-left##0 net@352#66nmos@64_poly-left##1 8.525
C1425 net@352#66nmos@64_poly-left##1 0 0.173fF
R1268 net@352#66nmos@64_poly-left##1 net@352#66nmos@64_poly-left##2 8.525
C1426 net@352#66nmos@64_poly-left##2 0 0.173fF
R1269 net@352#66nmos@64_poly-left##2 net@352#67pin@575_polysilicon-1 8.525
R1270 net@1115#13nmos@65_poly-left net@1115#13nmos@65_poly-left##0 6.717
C1427 net@1115#13nmos@65_poly-left##0 0 0.128fF
R1271 net@1115#13nmos@65_poly-left##0 net@1115#13nmos@65_poly-left##1 6.717
C1428 net@1115#13nmos@65_poly-left##1 0 0.128fF
R1272 net@1115#13nmos@65_poly-left##1 net@1115#14pin@585_polysilicon-1 6.717
R1273 net@1115#14pin@585_polysilicon-1 net@1115#14pin@585_polysilicon-1##0 8.525
C1429 net@1115#14pin@585_polysilicon-1##0 0 0.144fF
R1274 net@1115#14pin@585_polysilicon-1##0 net@1115#9pmos@65_poly-right 8.525
R1275 net@1115 net@1115#14pin@585_polysilicon-1 9.3
R1276 net@352#67pin@575_polysilicon-1 net@352#67pin@575_polysilicon-1##0 6.2
C1430 net@352#67pin@575_polysilicon-1##0 0 0.105fF
R1277 net@352#67pin@575_polysilicon-1##0 net@352#64pin@586_polysilicon-1 6.2
R1278 net@1072#11pin@608_polysilicon-1 net@1072#11pin@608_polysilicon-1##0 9.92
C1431 net@1072#11pin@608_polysilicon-1##0 0 0.236fF
R1279 net@1072#11pin@608_polysilicon-1##0 net@1072#11pin@608_polysilicon-1##1 9.92
C1432 net@1072#11pin@608_polysilicon-1##1 0 0.236fF
R1280 net@1072#11pin@608_polysilicon-1##1 net@1072#11pin@608_polysilicon-1##2 9.92
C1433 net@1072#11pin@608_polysilicon-1##2 0 0.236fF
R1281 net@1072#11pin@608_polysilicon-1##2 net@1072#11pin@608_polysilicon-1##3 9.92
C1434 net@1072#11pin@608_polysilicon-1##3 0 0.236fF
R1282 net@1072#11pin@608_polysilicon-1##3 net@1072#11pin@608_polysilicon-1##4 9.92
C1435 net@1072#11pin@608_polysilicon-1##4 0 0.236fF
R1283 net@1072#11pin@608_polysilicon-1##4 net@1072#11pin@608_polysilicon-1##5 9.92
C1436 net@1072#11pin@608_polysilicon-1##5 0 0.236fF
R1284 net@1072#11pin@608_polysilicon-1##5 net@1072#11pin@608_polysilicon-1##6 9.92
C1437 net@1072#11pin@608_polysilicon-1##6 0 0.236fF
R1285 net@1072#11pin@608_polysilicon-1##6 net@1072#11pin@608_polysilicon-1##7 9.92
C1438 net@1072#11pin@608_polysilicon-1##7 0 0.236fF
R1286 net@1072#11pin@608_polysilicon-1##7 net@1072#11pin@608_polysilicon-1##8 9.92
C1439 net@1072#11pin@608_polysilicon-1##8 0 0.236fF
R1287 net@1072#11pin@608_polysilicon-1##8 net@1072#11pin@608_polysilicon-1##9 9.92
C1440 net@1072#11pin@608_polysilicon-1##9 0 0.236fF
R1288 net@1072#11pin@608_polysilicon-1##9 net@1072#11pin@608_polysilicon-1##10 9.92
C1441 net@1072#11pin@608_polysilicon-1##10 0 0.236fF
R1289 net@1072#11pin@608_polysilicon-1##10 net@1072#11pin@608_polysilicon-1##11 9.92
C1442 net@1072#11pin@608_polysilicon-1##11 0 0.236fF
R1290 net@1072#11pin@608_polysilicon-1##11 net@1072#11pin@608_polysilicon-1##12 9.92
C1443 net@1072#11pin@608_polysilicon-1##12 0 0.236fF
R1291 net@1072#11pin@608_polysilicon-1##12 net@1072#11pin@608_polysilicon-1##13 9.92
C1444 net@1072#11pin@608_polysilicon-1##13 0 0.236fF
R1292 net@1072#11pin@608_polysilicon-1##13 net@1072#4pin@571_polysilicon-1 9.92
R1293 X3#58pmos@66_poly-right X3#58pmos@66_poly-right##0 7.75
C1445 X3#58pmos@66_poly-right##0 0 0.157fF
R1294 X3#58pmos@66_poly-right##0 X3#58pmos@66_poly-right##1 7.75
C1446 X3#58pmos@66_poly-right##1 0 0.157fF
R1295 X3#58pmos@66_poly-right##1 X3#58pmos@66_poly-right##2 7.75
C1447 X3#58pmos@66_poly-right##2 0 0.157fF
R1296 X3#58pmos@66_poly-right##2 X3#59pin@595_polysilicon-1 7.75
R1297 X3#60nmos@66_poly-right X3#60nmos@66_poly-right##0 5.425
R1298 X3#60nmos@66_poly-right##0 X3#61pin@614_polysilicon-1 5.425
R1299 X3#61pin@614_polysilicon-1 X3#61pin@614_polysilicon-1##0 9.419
C1448 X3#61pin@614_polysilicon-1##0 0 0.221fF
R1300 X3#61pin@614_polysilicon-1##0 X3#61pin@614_polysilicon-1##1 9.419
C1449 X3#61pin@614_polysilicon-1##1 0 0.221fF
R1301 X3#61pin@614_polysilicon-1##1 X3#61pin@614_polysilicon-1##2 9.419
C1450 X3#61pin@614_polysilicon-1##2 0 0.221fF
R1302 X3#61pin@614_polysilicon-1##2 X3#61pin@614_polysilicon-1##3 9.419
C1451 X3#61pin@614_polysilicon-1##3 0 0.221fF
R1303 X3#61pin@614_polysilicon-1##3 X3#61pin@614_polysilicon-1##4 9.419
C1452 X3#61pin@614_polysilicon-1##4 0 0.221fF
R1304 X3#61pin@614_polysilicon-1##4 X3#61pin@614_polysilicon-1##5 9.419
C1453 X3#61pin@614_polysilicon-1##5 0 0.221fF
R1305 X3#61pin@614_polysilicon-1##5 X3#61pin@614_polysilicon-1##6 9.419
C1454 X3#61pin@614_polysilicon-1##6 0 0.221fF
R1306 X3#61pin@614_polysilicon-1##6 X3#61pin@614_polysilicon-1##7 9.419
C1455 X3#61pin@614_polysilicon-1##7 0 0.221fF
R1307 X3#61pin@614_polysilicon-1##7 X3#61pin@614_polysilicon-1##8 9.419
C1456 X3#61pin@614_polysilicon-1##8 0 0.221fF
R1308 X3#61pin@614_polysilicon-1##8 X3#61pin@614_polysilicon-1##9 9.419
C1457 X3#61pin@614_polysilicon-1##9 0 0.221fF
R1309 X3#61pin@614_polysilicon-1##9 X3#61pin@614_polysilicon-1##10 9.419
C1458 X3#61pin@614_polysilicon-1##10 0 0.221fF
R1310 X3#61pin@614_polysilicon-1##10 X3#61pin@614_polysilicon-1##11 9.419
C1459 X3#61pin@614_polysilicon-1##11 0 0.221fF
R1311 X3#61pin@614_polysilicon-1##11 X3#62pin@615_polysilicon-1 9.419
R1312 X3#59pin@595_polysilicon-1 X3#59pin@595_polysilicon-1##0 8.525
C1460 X3#59pin@595_polysilicon-1##0 0 0.144fF
R1313 X3#59pin@595_polysilicon-1##0 X3#64pin@596_polysilicon-1 8.525
R1314 X3#64pin@596_polysilicon-1 X3#60nmos@66_poly-right 6.2
R1315 net@1072#13nmos@67_poly-left net@1072#13nmos@67_poly-left##0 8.525
C1461 net@1072#13nmos@67_poly-left##0 0 0.173fF
R1316 net@1072#13nmos@67_poly-left##0 net@1072#13nmos@67_poly-left##1 8.525
C1462 net@1072#13nmos@67_poly-left##1 0 0.173fF
R1317 net@1072#13nmos@67_poly-left##1 net@1072#13nmos@67_poly-left##2 8.525
C1463 net@1072#13nmos@67_poly-left##2 0 0.173fF
R1318 net@1072#13nmos@67_poly-left##2 net@1072#14pin@597_polysilicon-1 8.525
R1319 net@1162#13nmos@68_poly-left net@1162#13nmos@68_poly-left##0 6.717
C1464 net@1162#13nmos@68_poly-left##0 0 0.128fF
R1320 net@1162#13nmos@68_poly-left##0 net@1162#13nmos@68_poly-left##1 6.717
C1465 net@1162#13nmos@68_poly-left##1 0 0.128fF
R1321 net@1162#13nmos@68_poly-left##1 net@1162#14pin@607_polysilicon-1 6.717
R1322 net@1162#14pin@607_polysilicon-1 net@1162#14pin@607_polysilicon-1##0 8.525
C1466 net@1162#14pin@607_polysilicon-1##0 0 0.144fF
R1323 net@1162#14pin@607_polysilicon-1##0 net@1162#9pmos@68_poly-right 8.525
R1324 net@1162 net@1162#14pin@607_polysilicon-1 9.3
R1325 net@1072#14pin@597_polysilicon-1 net@1072#14pin@597_polysilicon-1##0 6.2
C1467 net@1072#14pin@597_polysilicon-1##0 0 0.105fF
R1326 net@1072#14pin@597_polysilicon-1##0 net@1072#11pin@608_polysilicon-1 6.2
R1327 X2#74pmos@69_poly-right X2#74pmos@69_poly-right##0 7.233
C1468 X2#74pmos@69_poly-right##0 0 0.137fF
R1328 X2#74pmos@69_poly-right##0 X2#74pmos@69_poly-right##1 7.233
C1469 X2#74pmos@69_poly-right##1 0 0.137fF
R1329 X2#74pmos@69_poly-right##1 X2#75pin@624_polysilicon-1 7.233
R1330 X2#75pin@624_polysilicon-1 X2#75pin@624_polysilicon-1##0 7.75
C1470 X2#75pin@624_polysilicon-1##0 0 0.147fF
R1331 X2#75pin@624_polysilicon-1##0 X2#75pin@624_polysilicon-1##1 7.75
C1471 X2#75pin@624_polysilicon-1##1 0 0.147fF
R1332 X2#75pin@624_polysilicon-1##1 X2#76nmos@69_poly-left 7.75
R1333 X2#77contact@269_metal-1-polysilicon-1 X2#75pin@624_polysilicon-1 8.68
R1334 X3#53pin@593_polysilicon-1 X3#67pin@634_metal-1 4.807
R1335 X3#62pin@615_polysilicon-1 X3#67pin@634_metal-1 4.856
R1336 X4#46contact@232_metal-1-polysilicon-1 X4#46contact@232_metal-1-polysilicon-1##0 5.397
C1472 X4#46contact@232_metal-1-polysilicon-1##0 0 25.188fF
R1337 X4#46contact@232_metal-1-polysilicon-1##0 X4#57pin@638_metal-1 5.397
R1338 net@1240 net@1240#1pin@646_polysilicon-1 9.3
R1339 X4#46contact@232_metal-1-polysilicon-1 X4#46contact@232_metal-1-polysilicon-1##0 9.3
C1473 X4#46contact@232_metal-1-polysilicon-1##0 0 0.157fF
R1340 X4#46contact@232_metal-1-polysilicon-1##0 X4#59pin@675_polysilicon-1 9.3
R1341 X4#60pmos@71_poly-left X4#60pmos@71_poly-left##0 6.975
C1474 X4#60pmos@71_poly-left##0 0 0.118fF
R1342 X4#60pmos@71_poly-left##0 X4#61pin@677_polysilicon-1 6.975
R1343 X4#61pin@677_polysilicon-1 X4#61pin@677_polysilicon-1##0 9.688
C1475 X4#61pin@677_polysilicon-1##0 0 0.231fF
R1344 X4#61pin@677_polysilicon-1##0 X4#61pin@677_polysilicon-1##1 9.688
C1476 X4#61pin@677_polysilicon-1##1 0 0.231fF
R1345 X4#61pin@677_polysilicon-1##1 X4#61pin@677_polysilicon-1##2 9.688
C1477 X4#61pin@677_polysilicon-1##2 0 0.231fF
R1346 X4#61pin@677_polysilicon-1##2 X4#61pin@677_polysilicon-1##3 9.688
C1478 X4#61pin@677_polysilicon-1##3 0 0.231fF
R1347 X4#61pin@677_polysilicon-1##3 X4#61pin@677_polysilicon-1##4 9.688
C1479 X4#61pin@677_polysilicon-1##4 0 0.231fF
R1348 X4#61pin@677_polysilicon-1##4 X4#61pin@677_polysilicon-1##5 9.688
C1480 X4#61pin@677_polysilicon-1##5 0 0.231fF
R1349 X4#61pin@677_polysilicon-1##5 X4#61pin@677_polysilicon-1##6 9.688
C1481 X4#61pin@677_polysilicon-1##6 0 0.231fF
R1350 X4#61pin@677_polysilicon-1##6 X4#61pin@677_polysilicon-1##7 9.688
C1482 X4#61pin@677_polysilicon-1##7 0 0.231fF
R1351 X4#61pin@677_polysilicon-1##7 X4#61pin@677_polysilicon-1##8 9.688
C1483 X4#61pin@677_polysilicon-1##8 0 0.231fF
R1352 X4#61pin@677_polysilicon-1##8 X4#61pin@677_polysilicon-1##9 9.688
C1484 X4#61pin@677_polysilicon-1##9 0 0.231fF
R1353 X4#61pin@677_polysilicon-1##9 X4#61pin@677_polysilicon-1##10 9.688
C1485 X4#61pin@677_polysilicon-1##10 0 0.231fF
R1354 X4#61pin@677_polysilicon-1##10 X4#61pin@677_polysilicon-1##11 9.688
C1486 X4#61pin@677_polysilicon-1##11 0 0.231fF
R1355 X4#61pin@677_polysilicon-1##11 X4#61pin@677_polysilicon-1##12 9.688
C1487 X4#61pin@677_polysilicon-1##12 0 0.231fF
R1356 X4#61pin@677_polysilicon-1##12 X4#61pin@677_polysilicon-1##13 9.688
C1488 X4#61pin@677_polysilicon-1##13 0 0.231fF
R1357 X4#61pin@677_polysilicon-1##13 X4#61pin@677_polysilicon-1##14 9.688
C1489 X4#61pin@677_polysilicon-1##14 0 0.231fF
R1358 X4#61pin@677_polysilicon-1##14 X4#62pin@678_polysilicon-1 9.688
R1359 X4#59pin@675_polysilicon-1 X4#59pin@675_polysilicon-1##0 8.525
C1490 X4#59pin@675_polysilicon-1##0 0 0.144fF
R1360 X4#59pin@675_polysilicon-1##0 X4#62pin@678_polysilicon-1 8.525
R1361 net@1246 net@1246##0 9.3
C1491 net@1246##0 0 0.157fF
R1362 net@1246##0 net@1246#1pin@679_polysilicon-1 9.3
R1363 net@1246#1pin@679_polysilicon-1 net@1246#1pin@679_polysilicon-1##0 8.525
C1492 net@1246#1pin@679_polysilicon-1##0 0 0.144fF
R1364 net@1246#1pin@679_polysilicon-1##0 net@1246#2pin@681_polysilicon-1 8.525
R1365 net@1246#3nmos@70_poly-right net@1246#3nmos@70_poly-right##0 6.975
C1493 net@1246#3nmos@70_poly-right##0 0 0.118fF
R1366 net@1246#3nmos@70_poly-right##0 net@1246#4pin@682_polysilicon-1 6.975
R1367 net@1246#4pin@682_polysilicon-1 net@1246#4pin@682_polysilicon-1##0 9.777
C1494 net@1246#4pin@682_polysilicon-1##0 0 0.23fF
R1368 net@1246#4pin@682_polysilicon-1##0 net@1246#4pin@682_polysilicon-1##1 9.777
C1495 net@1246#4pin@682_polysilicon-1##1 0 0.23fF
R1369 net@1246#4pin@682_polysilicon-1##1 net@1246#4pin@682_polysilicon-1##2 9.777
C1496 net@1246#4pin@682_polysilicon-1##2 0 0.23fF
R1370 net@1246#4pin@682_polysilicon-1##2 net@1246#4pin@682_polysilicon-1##3 9.777
C1497 net@1246#4pin@682_polysilicon-1##3 0 0.23fF
R1371 net@1246#4pin@682_polysilicon-1##3 net@1246#4pin@682_polysilicon-1##4 9.777
C1498 net@1246#4pin@682_polysilicon-1##4 0 0.23fF
R1372 net@1246#4pin@682_polysilicon-1##4 net@1246#4pin@682_polysilicon-1##5 9.777
C1499 net@1246#4pin@682_polysilicon-1##5 0 0.23fF
R1373 net@1246#4pin@682_polysilicon-1##5 net@1246#4pin@682_polysilicon-1##6 9.777
C1500 net@1246#4pin@682_polysilicon-1##6 0 0.23fF
R1374 net@1246#4pin@682_polysilicon-1##6 net@1246#4pin@682_polysilicon-1##7 9.777
C1501 net@1246#4pin@682_polysilicon-1##7 0 0.23fF
R1375 net@1246#4pin@682_polysilicon-1##7 net@1246#4pin@682_polysilicon-1##8 9.777
C1502 net@1246#4pin@682_polysilicon-1##8 0 0.23fF
R1376 net@1246#4pin@682_polysilicon-1##8 net@1246#4pin@682_polysilicon-1##9 9.777
C1503 net@1246#4pin@682_polysilicon-1##9 0 0.23fF
R1377 net@1246#4pin@682_polysilicon-1##9 net@1246#4pin@682_polysilicon-1##10 9.777
C1504 net@1246#4pin@682_polysilicon-1##10 0 0.23fF
R1378 net@1246#4pin@682_polysilicon-1##10 net@1246#4pin@682_polysilicon-1##11 9.777
C1505 net@1246#4pin@682_polysilicon-1##11 0 0.23fF
R1379 net@1246#4pin@682_polysilicon-1##11 net@1246#2pin@681_polysilicon-1 9.777
R1380 net@1246#5pmos@70_poly-right net@1246#5pmos@70_poly-right##0 9.817
C1506 net@1246#5pmos@70_poly-right##0 0 0.224fF
R1381 net@1246#5pmos@70_poly-right##0 net@1246#5pmos@70_poly-right##1 9.817
C1507 net@1246#5pmos@70_poly-right##1 0 0.224fF
R1382 net@1246#5pmos@70_poly-right##1 net@1246#5pmos@70_poly-right##2 9.817
C1508 net@1246#5pmos@70_poly-right##2 0 0.224fF
R1383 net@1246#5pmos@70_poly-right##2 net@1246#5pmos@70_poly-right##3 9.817
C1509 net@1246#5pmos@70_poly-right##3 0 0.224fF
R1384 net@1246#5pmos@70_poly-right##3 net@1246#5pmos@70_poly-right##4 9.817
C1510 net@1246#5pmos@70_poly-right##4 0 0.224fF
R1385 net@1246#5pmos@70_poly-right##4 net@1246#5pmos@70_poly-right##5 9.817
C1511 net@1246#5pmos@70_poly-right##5 0 0.224fF
R1386 net@1246#5pmos@70_poly-right##5 net@1246#5pmos@70_poly-right##6 9.817
C1512 net@1246#5pmos@70_poly-right##6 0 0.224fF
R1387 net@1246#5pmos@70_poly-right##6 net@1246#5pmos@70_poly-right##7 9.817
C1513 net@1246#5pmos@70_poly-right##7 0 0.224fF
R1388 net@1246#5pmos@70_poly-right##7 net@1246#6pin@642_polysilicon-1 9.817
R1389 net@1246#6pin@642_polysilicon-1 net@1246#6pin@642_polysilicon-1##0 7.233
C1514 net@1246#6pin@642_polysilicon-1##0 0 0.137fF
R1390 net@1246#6pin@642_polysilicon-1##0 net@1246#6pin@642_polysilicon-1##1 7.233
C1515 net@1246#6pin@642_polysilicon-1##1 0 0.137fF
R1391 net@1246#6pin@642_polysilicon-1##1 net@1246#3nmos@70_poly-right 7.233
R1392 net@1265 net@1265##0 9.3
C1516 net@1265##0 0 0.157fF
R1393 net@1265##0 net@1265#1contact@286_metal-1-polysilicon-1 9.3
R1394 net@1240#2contact@285_metal-1-polysilicon-1 net@1240#2contact@285_metal-1-polysilicon-1##0 9.3
C1517 net@1240#2contact@285_metal-1-polysilicon-1##0 0 0.157fF
R1395 net@1240#2contact@285_metal-1-polysilicon-1##0 net@1240#1pin@646_polysilicon-1 9.3
R1396 net@1252#5pmos@73_poly-right net@1252#5pmos@73_poly-right##0 8.913
C1518 net@1252#5pmos@73_poly-right##0 0 0.201fF
R1397 net@1252#5pmos@73_poly-right##0 net@1252#5pmos@73_poly-right##1 8.913
C1519 net@1252#5pmos@73_poly-right##1 0 0.201fF
R1398 net@1252#5pmos@73_poly-right##1 net@1252#5pmos@73_poly-right##2 8.913
C1520 net@1252#5pmos@73_poly-right##2 0 0.201fF
R1399 net@1252#5pmos@73_poly-right##2 net@1252#5pmos@73_poly-right##3 8.913
C1521 net@1252#5pmos@73_poly-right##3 0 0.201fF
R1400 net@1252#5pmos@73_poly-right##3 net@1252#5pmos@73_poly-right##4 8.913
C1522 net@1252#5pmos@73_poly-right##4 0 0.201fF
R1401 net@1252#5pmos@73_poly-right##4 net@1252#5pmos@73_poly-right##5 8.913
C1523 net@1252#5pmos@73_poly-right##5 0 0.201fF
R1402 net@1252#5pmos@73_poly-right##5 net@1252#5pmos@73_poly-right##6 8.913
C1524 net@1252#5pmos@73_poly-right##6 0 0.201fF
R1403 net@1252#5pmos@73_poly-right##6 net@1252#9pin@641_polysilicon-1 8.913
R1404 net@1252#11nmos@73_poly-left net@1252#11nmos@73_poly-left##0 9.688
C1525 net@1252#11nmos@73_poly-left##0 0 0.196fF
R1405 net@1252#11nmos@73_poly-left##0 net@1252#11nmos@73_poly-left##1 9.688
C1526 net@1252#11nmos@73_poly-left##1 0 0.196fF
R1406 net@1252#11nmos@73_poly-left##1 net@1252#11nmos@73_poly-left##2 9.688
C1527 net@1252#11nmos@73_poly-left##2 0 0.196fF
R1407 net@1252#11nmos@73_poly-left##2 net@1252#9pin@641_polysilicon-1 9.688
R1408 net@1252 net@1252#9pin@641_polysilicon-1 7.44
R1409 X4#63nmos@71_poly-left X4#63nmos@71_poly-left##0 9.3
C1528 X4#63nmos@71_poly-left##0 0 0.202fF
R1410 X4#63nmos@71_poly-left##0 X4#63nmos@71_poly-left##1 9.3
C1529 X4#63nmos@71_poly-left##1 0 0.202fF
R1411 X4#63nmos@71_poly-left##1 X4#63nmos@71_poly-left##2 9.3
C1530 X4#63nmos@71_poly-left##2 0 0.202fF
R1412 X4#63nmos@71_poly-left##2 X4#63nmos@71_poly-left##3 9.3
C1531 X4#63nmos@71_poly-left##3 0 0.202fF
R1413 X4#63nmos@71_poly-left##3 X4#63nmos@71_poly-left##4 9.3
C1532 X4#63nmos@71_poly-left##4 0 0.202fF
R1414 X4#63nmos@71_poly-left##4 X4#64pin@657_polysilicon-1 9.3
R1415 X4#64pin@657_polysilicon-1 X4#64pin@657_polysilicon-1##0 6.975
C1533 X4#64pin@657_polysilicon-1##0 0 0.118fF
R1416 X4#64pin@657_polysilicon-1##0 X4#65pin@658_polysilicon-1 6.975
R1417 X4#60pmos@71_poly-left X4#60pmos@71_poly-left##0 9.042
C1534 X4#60pmos@71_poly-left##0 0 0.196fF
R1418 X4#60pmos@71_poly-left##0 X4#60pmos@71_poly-left##1 9.042
C1535 X4#60pmos@71_poly-left##1 0 0.196fF
R1419 X4#60pmos@71_poly-left##1 X4#60pmos@71_poly-left##2 9.042
C1536 X4#60pmos@71_poly-left##2 0 0.196fF
R1420 X4#60pmos@71_poly-left##2 X4#60pmos@71_poly-left##3 9.042
C1537 X4#60pmos@71_poly-left##3 0 0.196fF
R1421 X4#60pmos@71_poly-left##3 X4#60pmos@71_poly-left##4 9.042
C1538 X4#60pmos@71_poly-left##4 0 0.196fF
R1422 X4#60pmos@71_poly-left##4 X4#65pin@658_polysilicon-1 9.042
R1423 net@1240#4nmos@72_poly-left net@1240#4nmos@72_poly-left##0 9.817
C1539 net@1240#4nmos@72_poly-left##0 0 0.213fF
R1424 net@1240#4nmos@72_poly-left##0 net@1240#4nmos@72_poly-left##1 9.817
C1540 net@1240#4nmos@72_poly-left##1 0 0.213fF
R1425 net@1240#4nmos@72_poly-left##1 net@1240#4nmos@72_poly-left##2 9.817
C1541 net@1240#4nmos@72_poly-left##2 0 0.213fF
R1426 net@1240#4nmos@72_poly-left##2 net@1240#4nmos@72_poly-left##3 9.817
C1542 net@1240#4nmos@72_poly-left##3 0 0.213fF
R1427 net@1240#4nmos@72_poly-left##3 net@1240#4nmos@72_poly-left##4 9.817
C1543 net@1240#4nmos@72_poly-left##4 0 0.213fF
R1428 net@1240#4nmos@72_poly-left##4 net@1240#5pin@660_polysilicon-1 9.817
R1429 net@1240#5pin@660_polysilicon-1 net@1240#5pin@660_polysilicon-1##0 6.975
C1544 net@1240#5pin@660_polysilicon-1##0 0 0.118fF
R1430 net@1240#5pin@660_polysilicon-1##0 net@1240#6pin@661_polysilicon-1 6.975
R1431 net@1240#6pin@661_polysilicon-1 net@1240#6pin@661_polysilicon-1##0 7.75
C1545 net@1240#6pin@661_polysilicon-1##0 0 0.157fF
R1432 net@1240#6pin@661_polysilicon-1##0 net@1240#6pin@661_polysilicon-1##1 7.75
C1546 net@1240#6pin@661_polysilicon-1##1 0 0.157fF
R1433 net@1240#6pin@661_polysilicon-1##1 net@1240#6pin@661_polysilicon-1##2 7.75
C1547 net@1240#6pin@661_polysilicon-1##2 0 0.157fF
R1434 net@1240#6pin@661_polysilicon-1##2 net@1240#7pin@662_polysilicon-1 7.75
R1435 net@1240#7pin@662_polysilicon-1 net@1240#7pin@662_polysilicon-1##0 9.3
C1548 net@1240#7pin@662_polysilicon-1##0 0 0.188fF
R1436 net@1240#7pin@662_polysilicon-1##0 net@1240#7pin@662_polysilicon-1##1 9.3
C1549 net@1240#7pin@662_polysilicon-1##1 0 0.188fF
R1437 net@1240#7pin@662_polysilicon-1##1 net@1240#7pin@662_polysilicon-1##2 9.3
C1550 net@1240#7pin@662_polysilicon-1##2 0 0.188fF
R1438 net@1240#7pin@662_polysilicon-1##2 net@1240#8pmos@72_poly-right 9.3
R1439 net@1265#4nmos@74_poly-left net@1265#4nmos@74_poly-left##0 9.3
C1551 net@1265#4nmos@74_poly-left##0 0 0.214fF
R1440 net@1265#4nmos@74_poly-left##0 net@1265#4nmos@74_poly-left##1 9.3
C1552 net@1265#4nmos@74_poly-left##1 0 0.214fF
R1441 net@1265#4nmos@74_poly-left##1 net@1265#4nmos@74_poly-left##2 9.3
C1553 net@1265#4nmos@74_poly-left##2 0 0.214fF
R1442 net@1265#4nmos@74_poly-left##2 net@1265#4nmos@74_poly-left##3 9.3
C1554 net@1265#4nmos@74_poly-left##3 0 0.214fF
R1443 net@1265#4nmos@74_poly-left##3 net@1265#4nmos@74_poly-left##4 9.3
C1555 net@1265#4nmos@74_poly-left##4 0 0.214fF
R1444 net@1265#4nmos@74_poly-left##4 net@1265#4nmos@74_poly-left##5 9.3
C1556 net@1265#4nmos@74_poly-left##5 0 0.214fF
R1445 net@1265#4nmos@74_poly-left##5 net@1265#4nmos@74_poly-left##6 9.3
C1557 net@1265#4nmos@74_poly-left##6 0 0.214fF
R1446 net@1265#4nmos@74_poly-left##6 net@1265#4nmos@74_poly-left##7 9.3
C1558 net@1265#4nmos@74_poly-left##7 0 0.214fF
R1447 net@1265#4nmos@74_poly-left##7 net@1265#4nmos@74_poly-left##8 9.3
C1559 net@1265#4nmos@74_poly-left##8 0 0.214fF
R1448 net@1265#4nmos@74_poly-left##8 net@1265#5pin@663_polysilicon-1 9.3
R1449 net@1265#5pin@663_polysilicon-1 net@1265#5pin@663_polysilicon-1##0 8.99
C1560 net@1265#5pin@663_polysilicon-1##0 0 0.19fF
R1450 net@1265#5pin@663_polysilicon-1##0 net@1265#5pin@663_polysilicon-1##1 8.99
C1561 net@1265#5pin@663_polysilicon-1##1 0 0.19fF
R1451 net@1265#5pin@663_polysilicon-1##1 net@1265#5pin@663_polysilicon-1##2 8.99
C1562 net@1265#5pin@663_polysilicon-1##2 0 0.19fF
R1452 net@1265#5pin@663_polysilicon-1##2 net@1265#5pin@663_polysilicon-1##3 8.99
C1563 net@1265#5pin@663_polysilicon-1##3 0 0.19fF
R1453 net@1265#5pin@663_polysilicon-1##3 net@1265#6pin@664_polysilicon-1 8.99
R1454 net@1265#6pin@664_polysilicon-1 net@1265#6pin@664_polysilicon-1##0 8.525
C1564 net@1265#6pin@664_polysilicon-1##0 0 0.144fF
R1455 net@1265#6pin@664_polysilicon-1##0 net@1265#7pmos@74_poly-right 8.525
R1456 net@1265#4nmos@74_poly-left net@1265#4nmos@74_poly-left##0 5.425
R1457 net@1265#4nmos@74_poly-left##0 net@1265#9pin@671_polysilicon-1 5.425
R1458 net@1265#9pin@671_polysilicon-1 net@1265#9pin@671_polysilicon-1##0 8.99
C1565 net@1265#9pin@671_polysilicon-1##0 0 0.19fF
R1459 net@1265#9pin@671_polysilicon-1##0 net@1265#9pin@671_polysilicon-1##1 8.99
C1566 net@1265#9pin@671_polysilicon-1##1 0 0.19fF
R1460 net@1265#9pin@671_polysilicon-1##1 net@1265#9pin@671_polysilicon-1##2 8.99
C1567 net@1265#9pin@671_polysilicon-1##2 0 0.19fF
R1461 net@1265#9pin@671_polysilicon-1##2 net@1265#9pin@671_polysilicon-1##3 8.99
C1568 net@1265#9pin@671_polysilicon-1##3 0 0.19fF
R1462 net@1265#9pin@671_polysilicon-1##3 net@1265#10pin@672_polysilicon-1 8.99
R1463 net@1265#10pin@672_polysilicon-1 net@1265#10pin@672_polysilicon-1##0 6.2
C1569 net@1265#10pin@672_polysilicon-1##0 0 0.105fF
R1464 net@1265#10pin@672_polysilicon-1##0 net@1265 6.2
R1465 net@1240#8pmos@72_poly-right net@1240#8pmos@72_poly-right##0 6.975
C1570 net@1240#8pmos@72_poly-right##0 0 0.118fF
R1466 net@1240#8pmos@72_poly-right##0 net@1240#10pin@673_polysilicon-1 6.975
R1467 net@1240#10pin@673_polysilicon-1 net@1240#10pin@673_polysilicon-1##0 9.864
C1571 net@1240#10pin@673_polysilicon-1##0 0 0.229fF
R1468 net@1240#10pin@673_polysilicon-1##0 net@1240#10pin@673_polysilicon-1##1 9.864
C1572 net@1240#10pin@673_polysilicon-1##1 0 0.229fF
R1469 net@1240#10pin@673_polysilicon-1##1 net@1240#10pin@673_polysilicon-1##2 9.864
C1573 net@1240#10pin@673_polysilicon-1##2 0 0.229fF
R1470 net@1240#10pin@673_polysilicon-1##2 net@1240#10pin@673_polysilicon-1##3 9.864
C1574 net@1240#10pin@673_polysilicon-1##3 0 0.229fF
R1471 net@1240#10pin@673_polysilicon-1##3 net@1240#10pin@673_polysilicon-1##4 9.864
C1575 net@1240#10pin@673_polysilicon-1##4 0 0.229fF
R1472 net@1240#10pin@673_polysilicon-1##4 net@1240#10pin@673_polysilicon-1##5 9.864
C1576 net@1240#10pin@673_polysilicon-1##5 0 0.229fF
R1473 net@1240#10pin@673_polysilicon-1##5 net@1240#10pin@673_polysilicon-1##6 9.864
C1577 net@1240#10pin@673_polysilicon-1##6 0 0.229fF
R1474 net@1240#10pin@673_polysilicon-1##6 net@1240#10pin@673_polysilicon-1##7 9.864
C1578 net@1240#10pin@673_polysilicon-1##7 0 0.229fF
R1475 net@1240#10pin@673_polysilicon-1##7 net@1240#10pin@673_polysilicon-1##8 9.864
C1579 net@1240#10pin@673_polysilicon-1##8 0 0.229fF
R1476 net@1240#10pin@673_polysilicon-1##8 net@1240#10pin@673_polysilicon-1##9 9.864
C1580 net@1240#10pin@673_polysilicon-1##9 0 0.229fF
R1477 net@1240#10pin@673_polysilicon-1##9 net@1240 9.864
R1478 net@352#74pin@697_polysilicon-1 net@352#74pin@697_polysilicon-1##0 9.92
C1581 net@352#74pin@697_polysilicon-1##0 0 0.236fF
R1479 net@352#74pin@697_polysilicon-1##0 net@352#74pin@697_polysilicon-1##1 9.92
C1582 net@352#74pin@697_polysilicon-1##1 0 0.236fF
R1480 net@352#74pin@697_polysilicon-1##1 net@352#74pin@697_polysilicon-1##2 9.92
C1583 net@352#74pin@697_polysilicon-1##2 0 0.236fF
R1481 net@352#74pin@697_polysilicon-1##2 net@352#74pin@697_polysilicon-1##3 9.92
C1584 net@352#74pin@697_polysilicon-1##3 0 0.236fF
R1482 net@352#74pin@697_polysilicon-1##3 net@352#74pin@697_polysilicon-1##4 9.92
C1585 net@352#74pin@697_polysilicon-1##4 0 0.236fF
R1483 net@352#74pin@697_polysilicon-1##4 net@352#74pin@697_polysilicon-1##5 9.92
C1586 net@352#74pin@697_polysilicon-1##5 0 0.236fF
R1484 net@352#74pin@697_polysilicon-1##5 net@352#74pin@697_polysilicon-1##6 9.92
C1587 net@352#74pin@697_polysilicon-1##6 0 0.236fF
R1485 net@352#74pin@697_polysilicon-1##6 net@352#74pin@697_polysilicon-1##7 9.92
C1588 net@352#74pin@697_polysilicon-1##7 0 0.236fF
R1486 net@352#74pin@697_polysilicon-1##7 net@352#74pin@697_polysilicon-1##8 9.92
C1589 net@352#74pin@697_polysilicon-1##8 0 0.236fF
R1487 net@352#74pin@697_polysilicon-1##8 net@352#74pin@697_polysilicon-1##9 9.92
C1590 net@352#74pin@697_polysilicon-1##9 0 0.236fF
R1488 net@352#74pin@697_polysilicon-1##9 net@352#74pin@697_polysilicon-1##10 9.92
C1591 net@352#74pin@697_polysilicon-1##10 0 0.236fF
R1489 net@352#74pin@697_polysilicon-1##10 net@352#74pin@697_polysilicon-1##11 9.92
C1592 net@352#74pin@697_polysilicon-1##11 0 0.236fF
R1490 net@352#74pin@697_polysilicon-1##11 net@352#74pin@697_polysilicon-1##12 9.92
C1593 net@352#74pin@697_polysilicon-1##12 0 0.236fF
R1491 net@352#74pin@697_polysilicon-1##12 net@352#74pin@697_polysilicon-1##13 9.92
C1594 net@352#74pin@697_polysilicon-1##13 0 0.236fF
R1492 net@352#74pin@697_polysilicon-1##13 net@352#7contact@97_metal-1-p-act 9.92
R1493 X2#79pmos@75_poly-right X2#79pmos@75_poly-right##0 7.75
C1595 X2#79pmos@75_poly-right##0 0 0.157fF
R1494 X2#79pmos@75_poly-right##0 X2#79pmos@75_poly-right##1 7.75
C1596 X2#79pmos@75_poly-right##1 0 0.157fF
R1495 X2#79pmos@75_poly-right##1 X2#79pmos@75_poly-right##2 7.75
C1597 X2#79pmos@75_poly-right##2 0 0.157fF
R1496 X2#79pmos@75_poly-right##2 X2#80pin@684_polysilicon-1 7.75
R1497 X2#81nmos@75_poly-right X2#81nmos@75_poly-right##0 5.425
R1498 X2#81nmos@75_poly-right##0 X2#82pin@703_polysilicon-1 5.425
R1499 X2#82pin@703_polysilicon-1 X2#82pin@703_polysilicon-1##0 9.419
C1598 X2#82pin@703_polysilicon-1##0 0 0.221fF
R1500 X2#82pin@703_polysilicon-1##0 X2#82pin@703_polysilicon-1##1 9.419
C1599 X2#82pin@703_polysilicon-1##1 0 0.221fF
R1501 X2#82pin@703_polysilicon-1##1 X2#82pin@703_polysilicon-1##2 9.419
C1600 X2#82pin@703_polysilicon-1##2 0 0.221fF
R1502 X2#82pin@703_polysilicon-1##2 X2#82pin@703_polysilicon-1##3 9.419
C1601 X2#82pin@703_polysilicon-1##3 0 0.221fF
R1503 X2#82pin@703_polysilicon-1##3 X2#82pin@703_polysilicon-1##4 9.419
C1602 X2#82pin@703_polysilicon-1##4 0 0.221fF
R1504 X2#82pin@703_polysilicon-1##4 X2#82pin@703_polysilicon-1##5 9.419
C1603 X2#82pin@703_polysilicon-1##5 0 0.221fF
R1505 X2#82pin@703_polysilicon-1##5 X2#82pin@703_polysilicon-1##6 9.419
C1604 X2#82pin@703_polysilicon-1##6 0 0.221fF
R1506 X2#82pin@703_polysilicon-1##6 X2#82pin@703_polysilicon-1##7 9.419
C1605 X2#82pin@703_polysilicon-1##7 0 0.221fF
R1507 X2#82pin@703_polysilicon-1##7 X2#82pin@703_polysilicon-1##8 9.419
C1606 X2#82pin@703_polysilicon-1##8 0 0.221fF
R1508 X2#82pin@703_polysilicon-1##8 X2#82pin@703_polysilicon-1##9 9.419
C1607 X2#82pin@703_polysilicon-1##9 0 0.221fF
R1509 X2#82pin@703_polysilicon-1##9 X2#82pin@703_polysilicon-1##10 9.419
C1608 X2#82pin@703_polysilicon-1##10 0 0.221fF
R1510 X2#82pin@703_polysilicon-1##10 X2#82pin@703_polysilicon-1##11 9.419
C1609 X2#82pin@703_polysilicon-1##11 0 0.221fF
R1511 X2#82pin@703_polysilicon-1##11 X2#83pin@704_polysilicon-1 9.419
R1512 X2#80pin@684_polysilicon-1 X2#80pin@684_polysilicon-1##0 8.525
C1610 X2#80pin@684_polysilicon-1##0 0 0.144fF
R1513 X2#80pin@684_polysilicon-1##0 X2#85pin@685_polysilicon-1 8.525
R1514 X2#85pin@685_polysilicon-1 X2#81nmos@75_poly-right 6.2
R1515 net@352#76nmos@76_poly-left net@352#76nmos@76_poly-left##0 8.525
C1611 net@352#76nmos@76_poly-left##0 0 0.173fF
R1516 net@352#76nmos@76_poly-left##0 net@352#76nmos@76_poly-left##1 8.525
C1612 net@352#76nmos@76_poly-left##1 0 0.173fF
R1517 net@352#76nmos@76_poly-left##1 net@352#76nmos@76_poly-left##2 8.525
C1613 net@352#76nmos@76_poly-left##2 0 0.173fF
R1518 net@352#76nmos@76_poly-left##2 net@352#77pin@686_polysilicon-1 8.525
R1519 net@1325#13nmos@77_poly-left net@1325#13nmos@77_poly-left##0 6.717
C1614 net@1325#13nmos@77_poly-left##0 0 0.128fF
R1520 net@1325#13nmos@77_poly-left##0 net@1325#13nmos@77_poly-left##1 6.717
C1615 net@1325#13nmos@77_poly-left##1 0 0.128fF
R1521 net@1325#13nmos@77_poly-left##1 net@1325#14pin@696_polysilicon-1 6.717
R1522 net@1325#14pin@696_polysilicon-1 net@1325#14pin@696_polysilicon-1##0 8.525
C1616 net@1325#14pin@696_polysilicon-1##0 0 0.144fF
R1523 net@1325#14pin@696_polysilicon-1##0 net@1325#9pmos@77_poly-right 8.525
R1524 net@1325 net@1325#14pin@696_polysilicon-1 9.3
R1525 net@352#77pin@686_polysilicon-1 net@352#77pin@686_polysilicon-1##0 6.2
C1617 net@352#77pin@686_polysilicon-1##0 0 0.105fF
R1526 net@352#77pin@686_polysilicon-1##0 net@352#74pin@697_polysilicon-1 6.2
R1527 net@1365#2pin@719_polysilicon-1 net@1365#2pin@719_polysilicon-1##0 9.92
C1618 net@1365#2pin@719_polysilicon-1##0 0 0.236fF
R1528 net@1365#2pin@719_polysilicon-1##0 net@1365#2pin@719_polysilicon-1##1 9.92
C1619 net@1365#2pin@719_polysilicon-1##1 0 0.236fF
R1529 net@1365#2pin@719_polysilicon-1##1 net@1365#2pin@719_polysilicon-1##2 9.92
C1620 net@1365#2pin@719_polysilicon-1##2 0 0.236fF
R1530 net@1365#2pin@719_polysilicon-1##2 net@1365#2pin@719_polysilicon-1##3 9.92
C1621 net@1365#2pin@719_polysilicon-1##3 0 0.236fF
R1531 net@1365#2pin@719_polysilicon-1##3 net@1365#2pin@719_polysilicon-1##4 9.92
C1622 net@1365#2pin@719_polysilicon-1##4 0 0.236fF
R1532 net@1365#2pin@719_polysilicon-1##4 net@1365#2pin@719_polysilicon-1##5 9.92
C1623 net@1365#2pin@719_polysilicon-1##5 0 0.236fF
R1533 net@1365#2pin@719_polysilicon-1##5 net@1365#2pin@719_polysilicon-1##6 9.92
C1624 net@1365#2pin@719_polysilicon-1##6 0 0.236fF
R1534 net@1365#2pin@719_polysilicon-1##6 net@1365#2pin@719_polysilicon-1##7 9.92
C1625 net@1365#2pin@719_polysilicon-1##7 0 0.236fF
R1535 net@1365#2pin@719_polysilicon-1##7 net@1365#2pin@719_polysilicon-1##8 9.92
C1626 net@1365#2pin@719_polysilicon-1##8 0 0.236fF
R1536 net@1365#2pin@719_polysilicon-1##8 net@1365#2pin@719_polysilicon-1##9 9.92
C1627 net@1365#2pin@719_polysilicon-1##9 0 0.236fF
R1537 net@1365#2pin@719_polysilicon-1##9 net@1365#2pin@719_polysilicon-1##10 9.92
C1628 net@1365#2pin@719_polysilicon-1##10 0 0.236fF
R1538 net@1365#2pin@719_polysilicon-1##10 net@1365#2pin@719_polysilicon-1##11 9.92
C1629 net@1365#2pin@719_polysilicon-1##11 0 0.236fF
R1539 net@1365#2pin@719_polysilicon-1##11 net@1365#2pin@719_polysilicon-1##12 9.92
C1630 net@1365#2pin@719_polysilicon-1##12 0 0.236fF
R1540 net@1365#2pin@719_polysilicon-1##12 net@1365#2pin@719_polysilicon-1##13 9.92
C1631 net@1365#2pin@719_polysilicon-1##13 0 0.236fF
R1541 net@1365#2pin@719_polysilicon-1##13 net@1365 9.92
R1542 X2#88pmos@78_poly-right X2#88pmos@78_poly-right##0 7.75
C1632 X2#88pmos@78_poly-right##0 0 0.157fF
R1543 X2#88pmos@78_poly-right##0 X2#88pmos@78_poly-right##1 7.75
C1633 X2#88pmos@78_poly-right##1 0 0.157fF
R1544 X2#88pmos@78_poly-right##1 X2#88pmos@78_poly-right##2 7.75
C1634 X2#88pmos@78_poly-right##2 0 0.157fF
R1545 X2#88pmos@78_poly-right##2 X2#89pin@706_polysilicon-1 7.75
R1546 X2#90nmos@78_poly-right X2#90nmos@78_poly-right##0 5.425
R1547 X2#90nmos@78_poly-right##0 X2#91pin@725_polysilicon-1 5.425
R1548 X2#91pin@725_polysilicon-1 X2#91pin@725_polysilicon-1##0 9.419
C1635 X2#91pin@725_polysilicon-1##0 0 0.221fF
R1549 X2#91pin@725_polysilicon-1##0 X2#91pin@725_polysilicon-1##1 9.419
C1636 X2#91pin@725_polysilicon-1##1 0 0.221fF
R1550 X2#91pin@725_polysilicon-1##1 X2#91pin@725_polysilicon-1##2 9.419
C1637 X2#91pin@725_polysilicon-1##2 0 0.221fF
R1551 X2#91pin@725_polysilicon-1##2 X2#91pin@725_polysilicon-1##3 9.419
C1638 X2#91pin@725_polysilicon-1##3 0 0.221fF
R1552 X2#91pin@725_polysilicon-1##3 X2#91pin@725_polysilicon-1##4 9.419
C1639 X2#91pin@725_polysilicon-1##4 0 0.221fF
R1553 X2#91pin@725_polysilicon-1##4 X2#91pin@725_polysilicon-1##5 9.419
C1640 X2#91pin@725_polysilicon-1##5 0 0.221fF
R1554 X2#91pin@725_polysilicon-1##5 X2#91pin@725_polysilicon-1##6 9.419
C1641 X2#91pin@725_polysilicon-1##6 0 0.221fF
R1555 X2#91pin@725_polysilicon-1##6 X2#91pin@725_polysilicon-1##7 9.419
C1642 X2#91pin@725_polysilicon-1##7 0 0.221fF
R1556 X2#91pin@725_polysilicon-1##7 X2#91pin@725_polysilicon-1##8 9.419
C1643 X2#91pin@725_polysilicon-1##8 0 0.221fF
R1557 X2#91pin@725_polysilicon-1##8 X2#91pin@725_polysilicon-1##9 9.419
C1644 X2#91pin@725_polysilicon-1##9 0 0.221fF
R1558 X2#91pin@725_polysilicon-1##9 X2#91pin@725_polysilicon-1##10 9.419
C1645 X2#91pin@725_polysilicon-1##10 0 0.221fF
R1559 X2#91pin@725_polysilicon-1##10 X2#91pin@725_polysilicon-1##11 9.419
C1646 X2#91pin@725_polysilicon-1##11 0 0.221fF
R1560 X2#91pin@725_polysilicon-1##11 X2#92pin@726_polysilicon-1 9.419
R1561 X2#89pin@706_polysilicon-1 X2#89pin@706_polysilicon-1##0 8.525
C1647 X2#89pin@706_polysilicon-1##0 0 0.144fF
R1562 X2#89pin@706_polysilicon-1##0 X2#94pin@707_polysilicon-1 8.525
R1563 X2#94pin@707_polysilicon-1 X2#90nmos@78_poly-right 6.2
R1564 net@1365#4nmos@79_poly-left net@1365#4nmos@79_poly-left##0 8.525
C1648 net@1365#4nmos@79_poly-left##0 0 0.173fF
R1565 net@1365#4nmos@79_poly-left##0 net@1365#4nmos@79_poly-left##1 8.525
C1649 net@1365#4nmos@79_poly-left##1 0 0.173fF
R1566 net@1365#4nmos@79_poly-left##1 net@1365#4nmos@79_poly-left##2 8.525
C1650 net@1365#4nmos@79_poly-left##2 0 0.173fF
R1567 net@1365#4nmos@79_poly-left##2 net@1365#5pin@708_polysilicon-1 8.525
R1568 net@1372#13nmos@80_poly-left net@1372#13nmos@80_poly-left##0 6.717
C1651 net@1372#13nmos@80_poly-left##0 0 0.128fF
R1569 net@1372#13nmos@80_poly-left##0 net@1372#13nmos@80_poly-left##1 6.717
C1652 net@1372#13nmos@80_poly-left##1 0 0.128fF
R1570 net@1372#13nmos@80_poly-left##1 net@1372#14pin@718_polysilicon-1 6.717
R1571 net@1372#14pin@718_polysilicon-1 net@1372#14pin@718_polysilicon-1##0 8.525
C1653 net@1372#14pin@718_polysilicon-1##0 0 0.144fF
R1572 net@1372#14pin@718_polysilicon-1##0 net@1372#9pmos@80_poly-right 8.525
R1573 net@1372 net@1372#14pin@718_polysilicon-1 9.3
R1574 net@1365#5pin@708_polysilicon-1 net@1365#5pin@708_polysilicon-1##0 6.2
C1654 net@1365#5pin@708_polysilicon-1##0 0 0.105fF
R1575 net@1365#5pin@708_polysilicon-1##0 net@1365#2pin@719_polysilicon-1 6.2
R1576 X3#71pin@741_polysilicon-1 X3#71pin@741_polysilicon-1##0 9.92
C1655 X3#71pin@741_polysilicon-1##0 0 0.236fF
R1577 X3#71pin@741_polysilicon-1##0 X3#71pin@741_polysilicon-1##1 9.92
C1656 X3#71pin@741_polysilicon-1##1 0 0.236fF
R1578 X3#71pin@741_polysilicon-1##1 X3#71pin@741_polysilicon-1##2 9.92
C1657 X3#71pin@741_polysilicon-1##2 0 0.236fF
R1579 X3#71pin@741_polysilicon-1##2 X3#71pin@741_polysilicon-1##3 9.92
C1658 X3#71pin@741_polysilicon-1##3 0 0.236fF
R1580 X3#71pin@741_polysilicon-1##3 X3#71pin@741_polysilicon-1##4 9.92
C1659 X3#71pin@741_polysilicon-1##4 0 0.236fF
R1581 X3#71pin@741_polysilicon-1##4 X3#71pin@741_polysilicon-1##5 9.92
C1660 X3#71pin@741_polysilicon-1##5 0 0.236fF
R1582 X3#71pin@741_polysilicon-1##5 X3#71pin@741_polysilicon-1##6 9.92
C1661 X3#71pin@741_polysilicon-1##6 0 0.236fF
R1583 X3#71pin@741_polysilicon-1##6 X3#71pin@741_polysilicon-1##7 9.92
C1662 X3#71pin@741_polysilicon-1##7 0 0.236fF
R1584 X3#71pin@741_polysilicon-1##7 X3#71pin@741_polysilicon-1##8 9.92
C1663 X3#71pin@741_polysilicon-1##8 0 0.236fF
R1585 X3#71pin@741_polysilicon-1##8 X3#71pin@741_polysilicon-1##9 9.92
C1664 X3#71pin@741_polysilicon-1##9 0 0.236fF
R1586 X3#71pin@741_polysilicon-1##9 X3#71pin@741_polysilicon-1##10 9.92
C1665 X3#71pin@741_polysilicon-1##10 0 0.236fF
R1587 X3#71pin@741_polysilicon-1##10 X3#71pin@741_polysilicon-1##11 9.92
C1666 X3#71pin@741_polysilicon-1##11 0 0.236fF
R1588 X3#71pin@741_polysilicon-1##11 X3#71pin@741_polysilicon-1##12 9.92
C1667 X3#71pin@741_polysilicon-1##12 0 0.236fF
R1589 X3#71pin@741_polysilicon-1##12 X3#71pin@741_polysilicon-1##13 9.92
C1668 X3#71pin@741_polysilicon-1##13 0 0.236fF
R1590 X3#71pin@741_polysilicon-1##13 X3#69contact@325_metal-1-polysilicon-1 9.92
R1591 net@1423 net@1423##0 7.75
C1669 net@1423##0 0 0.157fF
R1592 net@1423##0 net@1423##1 7.75
C1670 net@1423##1 0 0.157fF
R1593 net@1423##1 net@1423##2 7.75
C1671 net@1423##2 0 0.157fF
R1594 net@1423##2 net@1423#1pin@728_polysilicon-1 7.75
R1595 net@1423#2nmos@81_poly-right net@1423#2nmos@81_poly-right##0 5.425
R1596 net@1423#2nmos@81_poly-right##0 net@1423#3pin@747_polysilicon-1 5.425
R1597 net@1423#3pin@747_polysilicon-1 net@1423#3pin@747_polysilicon-1##0 9.419
C1672 net@1423#3pin@747_polysilicon-1##0 0 0.221fF
R1598 net@1423#3pin@747_polysilicon-1##0 net@1423#3pin@747_polysilicon-1##1 9.419
C1673 net@1423#3pin@747_polysilicon-1##1 0 0.221fF
R1599 net@1423#3pin@747_polysilicon-1##1 net@1423#3pin@747_polysilicon-1##2 9.419
C1674 net@1423#3pin@747_polysilicon-1##2 0 0.221fF
R1600 net@1423#3pin@747_polysilicon-1##2 net@1423#3pin@747_polysilicon-1##3 9.419
C1675 net@1423#3pin@747_polysilicon-1##3 0 0.221fF
R1601 net@1423#3pin@747_polysilicon-1##3 net@1423#3pin@747_polysilicon-1##4 9.419
C1676 net@1423#3pin@747_polysilicon-1##4 0 0.221fF
R1602 net@1423#3pin@747_polysilicon-1##4 net@1423#3pin@747_polysilicon-1##5 9.419
C1677 net@1423#3pin@747_polysilicon-1##5 0 0.221fF
R1603 net@1423#3pin@747_polysilicon-1##5 net@1423#3pin@747_polysilicon-1##6 9.419
C1678 net@1423#3pin@747_polysilicon-1##6 0 0.221fF
R1604 net@1423#3pin@747_polysilicon-1##6 net@1423#3pin@747_polysilicon-1##7 9.419
C1679 net@1423#3pin@747_polysilicon-1##7 0 0.221fF
R1605 net@1423#3pin@747_polysilicon-1##7 net@1423#3pin@747_polysilicon-1##8 9.419
C1680 net@1423#3pin@747_polysilicon-1##8 0 0.221fF
R1606 net@1423#3pin@747_polysilicon-1##8 net@1423#3pin@747_polysilicon-1##9 9.419
C1681 net@1423#3pin@747_polysilicon-1##9 0 0.221fF
R1607 net@1423#3pin@747_polysilicon-1##9 net@1423#3pin@747_polysilicon-1##10 9.419
C1682 net@1423#3pin@747_polysilicon-1##10 0 0.221fF
R1608 net@1423#3pin@747_polysilicon-1##10 net@1423#3pin@747_polysilicon-1##11 9.419
C1683 net@1423#3pin@747_polysilicon-1##11 0 0.221fF
R1609 net@1423#3pin@747_polysilicon-1##11 net@1423#4pin@748_polysilicon-1 9.419
R1610 net@1423#1pin@728_polysilicon-1 net@1423#1pin@728_polysilicon-1##0 8.525
C1684 net@1423#1pin@728_polysilicon-1##0 0 0.144fF
R1611 net@1423#1pin@728_polysilicon-1##0 net@1423#6pin@729_polysilicon-1 8.525
R1612 net@1423#6pin@729_polysilicon-1 net@1423#2nmos@81_poly-right 6.2
R1613 X3#73nmos@82_poly-left X3#73nmos@82_poly-left##0 8.525
C1685 X3#73nmos@82_poly-left##0 0 0.173fF
R1614 X3#73nmos@82_poly-left##0 X3#73nmos@82_poly-left##1 8.525
C1686 X3#73nmos@82_poly-left##1 0 0.173fF
R1615 X3#73nmos@82_poly-left##1 X3#73nmos@82_poly-left##2 8.525
C1687 X3#73nmos@82_poly-left##2 0 0.173fF
R1616 X3#73nmos@82_poly-left##2 X3#74pin@730_polysilicon-1 8.525
R1617 net@1419#13nmos@83_poly-left net@1419#13nmos@83_poly-left##0 6.717
C1688 net@1419#13nmos@83_poly-left##0 0 0.128fF
R1618 net@1419#13nmos@83_poly-left##0 net@1419#13nmos@83_poly-left##1 6.717
C1689 net@1419#13nmos@83_poly-left##1 0 0.128fF
R1619 net@1419#13nmos@83_poly-left##1 net@1419#14pin@740_polysilicon-1 6.717
R1620 net@1419#14pin@740_polysilicon-1 net@1419#14pin@740_polysilicon-1##0 8.525
C1690 net@1419#14pin@740_polysilicon-1##0 0 0.144fF
R1621 net@1419#14pin@740_polysilicon-1##0 net@1419#9pmos@83_poly-right 8.525
R1622 net@1419 net@1419#14pin@740_polysilicon-1 9.3
R1623 X3#74pin@730_polysilicon-1 X3#74pin@730_polysilicon-1##0 6.2
C1691 X3#74pin@730_polysilicon-1##0 0 0.105fF
R1624 X3#74pin@730_polysilicon-1##0 X3#71pin@741_polysilicon-1 6.2
R1625 X3#79pmos@84_poly-right X3#79pmos@84_poly-right##0 7.233
C1692 X3#79pmos@84_poly-right##0 0 0.137fF
R1626 X3#79pmos@84_poly-right##0 X3#79pmos@84_poly-right##1 7.233
C1693 X3#79pmos@84_poly-right##1 0 0.137fF
R1627 X3#79pmos@84_poly-right##1 X3#80pin@749_polysilicon-1 7.233
R1628 X3#80pin@749_polysilicon-1 X3#80pin@749_polysilicon-1##0 7.75
C1694 X3#80pin@749_polysilicon-1##0 0 0.147fF
R1629 X3#80pin@749_polysilicon-1##0 X3#80pin@749_polysilicon-1##1 7.75
C1695 X3#80pin@749_polysilicon-1##1 0 0.147fF
R1630 X3#80pin@749_polysilicon-1##1 X3#81nmos@84_poly-left 7.75
R1631 X3#69contact@325_metal-1-polysilicon-1 X3#80pin@749_polysilicon-1 8.68
R1632 X2#97pmos@85_poly-right X2#97pmos@85_poly-right##0 7.233
C1696 X2#97pmos@85_poly-right##0 0 0.137fF
R1633 X2#97pmos@85_poly-right##0 X2#97pmos@85_poly-right##1 7.233
C1697 X2#97pmos@85_poly-right##1 0 0.137fF
R1634 X2#97pmos@85_poly-right##1 X2#98pin@754_polysilicon-1 7.233
R1635 X2#98pin@754_polysilicon-1 X2#98pin@754_polysilicon-1##0 7.75
C1698 X2#98pin@754_polysilicon-1##0 0 0.147fF
R1636 X2#98pin@754_polysilicon-1##0 X2#98pin@754_polysilicon-1##1 7.75
C1699 X2#98pin@754_polysilicon-1##1 0 0.147fF
R1637 X2#98pin@754_polysilicon-1##1 X2#99nmos@85_poly-left 7.75
R1638 X2#100contact@331_metal-1-polysilicon-1 X2#98pin@754_polysilicon-1 8.68
R1639 X1#60pin@505_metal-1 X1#64pin@969_metal-1 8.073
R1640 X1 X1#66pin@971_metal-1 6.211
R1641 X1#66pin@971_metal-1 X1#67pin@968_metal-1 7.303
R1642 X1#34contact@96_metal-1-polysilicon-1 X1#66pin@971_metal-1 8.482
R1643 X2#11pin@90_metal-1 X2 6.542
R1644 X2#23contact@91_metal-1-polysilicon-1 X2 5.45
R1645 X2 X2#113pin@981_metal-1 5.84
R1646 X2#44pin@295_metal-1 X2#113pin@981_metal-1 7.449
R1647 X2#73pin@496_metal-1 X2#113pin@981_metal-1 7.449
R1648 X2#72pin@494_metal-1 X2#113pin@981_metal-1 7.42
R1649 X2#67contact@207_metal-1-polysilicon-1 X2#113pin@981_metal-1 7.459
R1650 X1#41contact@158_metal-1-polysilicon-1 X1#64pin@969_metal-1 7.186
R1651 X1#67pin@968_metal-1 X1#64pin@969_metal-1 4.339
R1652 X2#77contact@269_metal-1-polysilicon-1 X2#113pin@981_metal-1 7.42
R1653 X2#83pin@704_polysilicon-1 X2#113pin@981_metal-1 9.896
R1654 X2#100contact@331_metal-1-polysilicon-1 X2#100contact@331_metal-1-polysilicon-1##0 5.192
C1700 X2#100contact@331_metal-1-polysilicon-1##0 0 24.232fF
R1655 X2#100contact@331_metal-1-polysilicon-1##0 X2#113pin@981_metal-1 5.192
R1656 X2#92pin@726_polysilicon-1 X2#113pin@981_metal-1 8.697
R1657 X3#0contact@17_metal-1-polysilicon-1 X3 5.333
R1658 X3#21contact@108_metal-1-polysilicon-1 X3 6.445
R1659 X3#37contact@197_metal-1-polysilicon-1 X3 6.24
R1660 X3#42contact@202_metal-1-polysilicon-1 X3 5.85
R1661 X3#23contact@152_metal-1-polysilicon-1 X3 6.386
R1662 X4#57pin@638_metal-1 X4 5.207
R1663 X4#25pin@233_metal-1 X4 4.817
R1664 X4#32pin@300_metal-1 X4 4.602
R1665 X4#45pin@479_metal-1 X4 4.105
R1666 net@352#18contact@119_metal-1-polysilicon-1 net@352#7contact@97_metal-1-p-act 7.205
R1667 X3#67pin@634_metal-1 X3 4.583
R1668 X3#69contact@325_metal-1-polysilicon-1 X3 7.576

* Spice Code nodes in cell cell '7_segment_display{lay}'
.incude C:\Electric\MODEL_MOS.txt
VDD VDD 0 DC 3.3
VGND GND 0 DC 0
VX1 X1 0 DC 3.3
VX2 X2 0 DC 0
VX3 X3 0 DC 0
VX4 X4 0 DC 0
.tran 0 40n
.END
